# Allegro board TSW1418_E2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1V: length 44.2
  TOP w0.152: v1(48.04,35.32) 47.64,35.72 U9.M10 ; v1(46.44,34.52) 46.84,34.92 U9.N9
  TOP w0.254: v1(45.64,40.92) 46.04,40.52 U9.F8 ; U9.M8 46.04,35.72 v1(45.64,35.32) ; U9.G11 v1(48.84,40.12) ; U9.K8 v1(45.64,36.92) ; C95.1 v1(121.18,59.16) ; v1(48.84,34.52) 48.44,34.92 U9.N11 ; U9.L11 v1(48.84,36.12) ; U9.G9 v1(46.44,40.12) ; U9.J11 v1(48.84,38.52) ; v1(44.84,34.52) 45.24,34.92 U9.N7 ; v1(48.04,40.92) 47.64,40.52 U9.F10 ; U9.L7 v1(44.84,36.12) ; U9.J7 v1(44.84,38.52) ; U9.G7 v1(44.84,40.12) ; U9.H8 v1(45.64,39.32)
  TOP w0.457: 118.96,63.21 TP16.1 ; TP16.1 120.02,63.58 ; TP16.1 121.07,61.1 ; TP16.1 120.02,60.73 ; TP16.1 118.96,61.1 ; TP16.1 121.44,62.15 ; TP16.1 121.07,63.21 ; TP16.1 118.59,62.15
  LY7-PWR w0.254: 48.39,40.64 48.84,40.18 v1(48.84,40.12) ; v1(48.84,38.52) 48.84,37.77
  LY7-PWR w0.432: TP16.1 121.44,62.15 ; TP16.1 121.07,61.1 ; TP16.1 121.07,63.21 ; TP16.1 120.02,60.73 ; TP16.1 120.02,63.58 ; TP16.1 118.59,62.15 ; TP16.1 118.96,61.1 ; TP16.1 118.96,63.21
  BOTTOM w0.254: C78.1 44.75,38.43 v1(44.84,38.52) ; C36.1 45.86,35.1 v1(45.64,35.32) ; C76.1 47.98,35.38 v1(48.04,35.32) ; C77.1 48.97,34.39 v1(48.84,34.52) ; v1(45.64,40.92) 45.64,40.97 C75.1 ; v1(46.74,48.13) 46.63,47.98 C38.1 46.6,46.92 v1(45.85,47.5) ; C82.1 46.84,34.52 v1(46.44,34.52) ; v1(44.84,40.12) 44.78,40.06 C79.1 ; C80.1 48.84,38.18 v1(48.84,38.52) ; C70.1 44.82,34.49 v1(44.84,34.52) ; v1(48.84,36.12) 48.72,35.99 C37.1 ; C81.1 v1(45.64,36.92) ; C83.1 46.53,40.21 v1(46.44,40.12) ; C74.1 45.95,39.32 v1(45.64,39.32) ; C73.1 48.08,40.96 v1(48.04,40.92) ; v1(48.84,40.12) 48.69,40.27 C71.1 ; C72.1 45.03,36.31 v1(44.84,36.12)
  BOTTOM w0.508: C69.1 49.25,28.96 v1(48.9,28.96)
  vias: v1(116.28,59.92) v1(116.28,58.57) v1(116.28,57.07) v1(116.26,55.09) v1(116.74,56.11) v1(116.97,62.81) v1(116.97,61.44) v1(117.32,59.51) v1(117.32,57.78) v1(117.55,55.68) v1(117.88,63.55) v1(117.88,62.18) v1(118.03,59.89) v1(118.01,56.72) v1(118.08,58.7) v1(118.52,57.86) v1(118.69,59.51) v1(118.85,54.86) v1(119.1,55.68) v1(119.48,59) v1(119.51,56.62) v1(119.89,54.81) v1(119.99,59.66) v1(120.02,55.68) v1(120.19,59.08) v1(120.62,54.89) v1(120.78,58.98) v1(120.88,57.1) v1(120.88,56.34) v1(120.85,55.45) v1(121.49,55.73) v1(121.84,57.05)
2.5V: length 63.8
  TOP w0.457: TP4.1 115.19,31.52 ; TP4.1 113.77,30.1 ; TP4.1 115.19,28.68 ; TP4.1 116.61,30.1 ; TP4.1 114.13,29.04 ; TP4.1 116.25,31.16 ; TP4.1 114.13,31.16 ; TP4.1 116.25,29.04 ; 114.5,23.67 J13.1 ; J13.1 115.44,21.79 ; J13.1 116.38,22.73 ; J13.1 116.38,21.79 ; J13.1 116.38,23.67 ; J13.1 114.5,22.73 ; J13.1 114.5,21.79 ; J13.1 115.44,23.67
  TOP w0.508: C122.1 120.72,31.92 v1(120.72,31.24) U1.5
  LY7-PWR w0.432: 114.13,29.04 TP4.1 ; TP4.1 115.19,31.52 ; TP4.1 116.25,31.16 ; TP4.1 114.13,31.16 ; TP4.1 113.77,30.1 ; TP4.1 116.25,29.04 ; TP4.1 115.19,28.68 ; TP4.1 116.61,30.1 ; J13.1 116.16,22.02 ; J13.1 114.73,22.02 ; J13.1 114.73,23.45 ; J13.1 115.44,23.67 ; J13.1 115.44,21.79 ; J13.1 116.16,23.45 ; J13.1 114.5,22.73 ; J13.1 116.38,22.73
  BOTTOM w0.457: J13.1 116.38,23.67 ; J13.1 116.38,21.79 ; J13.1 114.5,23.67 ; J13.1 116.38,22.73 ; J13.1 114.5,21.79 ; J13.1 115.44,21.79 ; J13.1 115.44,23.67 ; J13.1 114.5,22.73 ; 114.13,29.04 TP4.1 ; TP4.1 116.25,29.04 ; TP4.1 116.61,30.1 ; TP4.1 116.25,31.16 ; TP4.1 115.19,31.52 ; TP4.1 115.19,28.68 ; TP4.1 113.77,30.1 ; TP4.1 114.13,31.16
  BOTTOM w0.508: C118.1 120.72,30.19 v1(120.72,31.24)
  vias: v1(113.67,32.51) v1(113.67,31.24) v1(113.67,29.08) v1(113.67,28.19) v1(114.3,31.88) v1(115.06,32.51) v1(115.06,28.19) v1(115.95,31.75) v1(116.46,32.51) v1(116.59,28.19) v1(117.22,31.88) v1(117.22,31.11) v1(117.22,29.72) v1(117.86,32.51) v1(118.36,31.11) v1(118.62,31.88) v1(118.75,30.35) v1(119.13,32.51) v1(119.51,31.11) v1(119.89,29.59) v1(120.14,31.95) v1(120.14,30.48) v1(120.47,32.61) v1(121.13,32.64) v1(121.28,31.42) v1(121.28,30.86)
3.3V: length 96.4
  TOP w0.152: U14.6 v1(133.46,13.04)
  TOP w0.254: C25.1 91.41,27.82 ; v1(50.55,43.31) 50.43,43.31 50.04,42.92 U9.C13 ; v1(123.17,17.76) U17.6 v1(123.17,15.77) ; v1(124.21,40.11) 124.28,40.03 124.71,40.03 ; 124.71,40.03 C99.1 ; 124.71,40.03 v1(124.23,40.51) ; v1(133.73,15.11) 133.46,14.84 U14.6 ; U9.G15 v1(52.04,40.12) ; U14.2 v1(131.96,11.17) ; U16.6 133.46,40.7 v1(133.48,40.72) ; U3.15 v1(81.9,43.16) ; U9.A17 v1(53.24,44.93) ; U9.K14 v1(51.24,36.92) ; v1(46.44,32.92) 46.84,33.32 U9.R9 ; U9.B10 v1(48.04,44.12) ; U15.8 131.36,54.43 ; U9.D16 v1(52.84,42.52) ; U9.H18 v1(54.43,38.92)
  TOP w0.381: 110.34,32.92 109.93,32.92 v1(109.73,32.72) ; 110.34,32.92 C124.1 ; 110.34,32.92 v1(109.73,32.31) ; v1(124.23,16.51) 124.38,16.66 124.49,16.66 ; R85.2 v1(98.68,35.56) ; v1(111.12,23.39) 111.02,23.5 111.02,23.7 ; C125.1 111.02,23.7 ; 111.02,23.7 v1(110.72,23.39) ; D6.1 v1(55.75,9.4) ; 124.49,16.66 C120.1 ; 124.49,16.66 v1(124.23,16.92) ; R12.1 v1(65.41,40.89) ; D7.1 v1(55.63,13.84) ; U12.6 v1(123.17,41) ; R91.1 v1(59.44,35.13) ; R87.1 v1(66.01,26.14) ; R90.1 v1(56.31,20.65) ; R24.1 v1(50.29,26.16) ; R20.1 v1(48.01,26.16) ; v1(130.61,58.83) 130.61,59.13 C108.1 ; R88.1 v1(69.82,24.66) ; v1(131.06,58.83) 131.06,59.28 C108.1 ; 131.36,54.43 v1(131.36,55.2) ; C111.1 v1(134.87,39.19) ; R79.1 v1(92.46,26.54) ; C110.1 v1(130.66,56.69) ; R63.1 v1(131.34,56.11) ; D5.1 v1(55.5,18.29) ; C25.1 v1(91.41,26.95) ; U18.13 v1(71.25,21.72) ; R25.1 v1(46.1,26.16) ; C108.1 v1(131.5,59) ; v1(110.26,36.78) 110.36,36.88 C126.1 109.83,37.36 v1(109.73,37.26) ; R22.1 v1(49.15,26.16) ; D4.1 v1(55.5,27.18) ; v1(134.92,13.41) 135.13,13.61 C105.1 v1(134.52,14) 134.49,13.97 ; D3.1 v1(55.63,22.73) ; U18.14 v1(69.88,23.59) ; R19.2 v1(89.79,28.07) ; 91.41,27.82 U7.16 ; R80.1 v1(99.82,30.86) ; U16.6 v1(133.95,39.79) ; R21.1 v1(44.96,26.16) ; R89.1 v1(60.76,29.92)
  TOP w0.457: 124.67,42.25 TP6.1 ; TP6.1 124.31,43.31 ; TP6.1 126.79,42.25 ; TP6.1 125.73,41.88 ; TP6.1 124.67,44.36 ; TP6.1 126.79,44.36 ; TP6.1 127.15,43.31 ; TP6.1 125.73,44.73
  TOP w0.508: C88.2 v1(42.29,50.8) ; Y2.4 v1(70.23,49.91) ; v1(124.33,16.1) C120.1 ; C84.1 v1(69.85,48.13) ; R86.1 v1(107.65,28.53) ; v1(110.13,32.33) C124.1 110.33,32.95 U10.5 ; C105.1 v1(134.54,13.51) ; R15.2 v1(58.27,51.08) ; R39.1 v1(46.74,49.78) ; U8.5 110.33,37.4 C126.1 v1(109.83,36.8) ; C125.1 v1(110.44,23.7) ; U20.8 v1(110.02,22.44) ; v1(124.21,39.7) C99.1 ; C86.2 v1(46.74,50.8) ; R37.1 v1(72.01,50.8) ; J3.2 v1(88.62,24.99) ; R41.1 v1(42.29,49.78)
  LYR9-PWR w0.457: 124.67,42.25 TP6.1 ; TP6.1 126.79,42.25 ; TP6.1 126.79,44.36 ; TP6.1 124.31,43.31 ; TP6.1 125.73,44.73 ; TP6.1 127.15,43.31 ; TP6.1 124.67,44.36 ; TP6.1 125.73,41.88
  BOTTOM w0.254: C63.1 52.03,40.13 v1(52.04,40.12) ; R93.1 v1(10.29,62.23) ; R94.1 v1(12.83,62.23) ; v1(81.9,43.16) 80.15,43.16 C17.1 ; v1(52.84,42.52) 53.21,42.15 C64.1 ; C66.1 54.62,39.12 v1(54.43,38.92) ; v1(48.04,44.12) 48.04,44.11 C39.1 ; C62.1 v1(50.55,43.31) ; C65.1 53.21,44.96 v1(53.24,44.93) ; R95.1 v1(7.75,62.23)
  BOTTOM w0.508: v1(54.99,41.15) C61.1 v1(56.01,42.42)
  vias: v1(57.53,28.45) v1(57.66,26.16) v1(57.78,29.21) v1(58.67,28.45) v1(58.8,26.29) v1(58.93,29.21) v1(59.69,30.1) v1(59.82,28.45) v1(59.94,26.29) v1(60.2,29.21) v1(60.96,28.45) v1(61.21,26.29) v1(61.34,29.21) v1(87.38,27.81) v1(87.5,25.02) v1(87.5,23.75) v1(88.14,28.57) v1(88.9,27.18) v1(89.66,24.89) v1(90.3,27.3) v1(91.57,24.77) v1(123.49,17.22) v1(123.62,40.41) v1(123.62,39.8) v1(123.65,17.7) v1(123.6,16.76) v1(123.8,41.1) v1(124.13,17.7) v1(124.54,17.27) v1(124.64,41.05) v1(124.76,17.73) v1(125.35,40.77) v1(125.53,40.01) v1(130.2,54.94) v1(130.56,55.42) v1(130.84,54.94) v1(131.04,56.46) v1(131.06,55.78) v1(131.47,56.69) v1(131.75,55.5) v1(132.11,56.67) v1(133.83,14.12) v1(133.86,13.51) v1(133.99,39.22) v1(134.11,40.72) v1(134.06,14.61) v1(134.44,15.14) v1(134.52,40.16) v1(134.47,39.7) v1(134.77,40.74) v1(134.8,14.63) v1(135.23,15.09) v1(135.51,40.74) v2(12.83,20.78) v2(12.83,15.7) v2(12.83,13.16) v2(12.83,10.62) v2(14.1,11.89)
3.3V_USB: length 22.4
  TOP w0.254: U4.42 v1(94.98,39.13)
  TOP w0.381: R9.1 v1(103.63,45.97) ; U6.5 v1(71.99,39) ; R1.1 v1(84.96,40.64) ; R2.1 v1(103.5,42.67) ; U4.20 v1(89.88,45.68) ; 72.64,36.7 v1(73.41,36.7) ; U4.56 v1(98.68,43.18) ; C20.1 112.01,52.32 v1(111.76,52.07) ; 112.42,52.22 v1(111.76,51.56) ; C24.1 v1(71.15,40.41) ; U4.50 v1(98.37,40.18) ; U4.31 v1(89.86,40.18) ; R8.1 v1(103.63,49.4) ; R13.1 v1(65.41,36.58) ; R7.1 v1(104.27,51.69) ; R4.1 v1(89.28,52.58)
  TOP w0.508: C3.1 v1(109.4,43.56) ; C20.1 112.42,51.59 v1(112.31,51.47) U5.8 ; U2.5 v1(110.06,42.72)
  BOTTOM w0.254: FB2.2 v1(98.55,52.32) ; FB1.2 v1(92.2,52.32) ; v1(89.86,40.18) 90.58,40.18 C9.1 ; v1(98.68,43.18) 98.07,43.18 C10.1 ; C8.1 94.98,39.74 v1(94.98,39.13) ; C11.1 90.62,45.68 v1(89.88,45.68)
  vias: v1(102.74,37.47) v1(109.42,43.13) v1(109.86,43.21) v1(118.57,35.66)
5V_EXT: length 38.3
  LYR9-PWR w0.457: TP10.1 117.82,47.08 ; TP10.1 115.71,47.08 ; TP10.1 115.71,44.97 ; TP10.1 115.34,46.02 ; TP10.1 116.76,44.6 ; TP10.1 117.82,44.97 ; TP10.1 118.19,46.02 ; TP10.1 116.76,47.45 ; J10.1 127.08,67.23 ; J10.1 126.36,67.01 ; J10.1 127.3,67.94 ; J10.1 125.65,67.23 ; J10.1 127.08,68.66 ; J10.1 125.65,68.66 ; J10.1 126.36,68.88 ; J10.1 125.43,67.94 ; J4.1 114.21,59.06 ; J4.1 112.52,59.69 ; J4.1 114.83,57.38 ; J4.1 110.84,55.69 ; J4.1 112.52,55.07 ; J4.1 114.21,55.69 ; J4.1 110.21,57.38 ; J4.1 110.84,59.06
5V_PWR: length 89.1
  TOP w0.254: v1(120.19,45.87) 120.83,45.24 R53.1 ; R75.1 v1(121.16,24.13) ; R50.2 v1(117.6,53.52)
  TOP w0.279: R71.1 120.9,22.23 120.4,22.73 120.4,24.03 R75.1
  TOP w0.457: 123.83,67.01 J10.2 ; J10.2 124.54,67.23 ; J10.2 124.54,68.66 ; J10.2 123.83,68.88 ; J10.2 123.11,68.66 ; J10.2 123.11,67.23 ; J10.2 122.89,67.94 ; J10.2 124.76,67.94 ; TP15.1 129.83,62.65 ; TP15.1 128.78,60.17 ; TP15.1 127.72,62.65 ; TP15.1 130.2,61.59 ; TP15.1 127.36,61.59 ; TP15.1 129.83,60.54 ; TP15.1 128.78,63.02 ; TP15.1 127.72,60.54
  TOP w0.508: v1(117.17,53.64) R50.2 v1(118.06,53.64) ; C91.1 v1(127.13,63.63) ; C91.1 v1(123.57,63.63) ; C91.1 v1(125.35,65.02)
  LY5-SIGNAL w0.432: 127.36,61.59 TP15.1 ; TP15.1 129.83,62.65 ; TP15.1 127.72,60.54 ; TP15.1 130.2,61.59 ; TP15.1 128.78,60.17 ; TP15.1 129.83,60.54 ; TP15.1 127.72,62.65 ; TP15.1 128.78,63.02 ; J10.2 124.76,67.94 ; J10.2 124.54,67.23 ; J10.2 123.11,68.66 ; J10.2 124.54,68.66 ; J10.2 123.83,67.01 ; J10.2 123.11,67.23 ; J10.2 122.89,67.94 ; J10.2 123.83,68.88
  LY7-PWR w0.432: J10.2 124.54,67.23 ; J10.2 123.11,68.66 ; J10.2 124.76,67.94 ; J10.2 123.83,68.88 ; J10.2 123.11,67.23 ; J10.2 124.54,68.66 ; J10.2 123.83,67.01 ; J10.2 122.89,67.94 ; 127.72,62.65 TP15.1 ; TP15.1 129.83,62.65 ; TP15.1 127.72,60.54 ; TP15.1 130.2,61.59 ; TP15.1 129.83,60.54 ; TP15.1 128.78,60.17 ; TP15.1 128.78,63.02 ; TP15.1 127.36,61.59
  BOTTOM w0.457: J10.2 124.54,68.66 ; J10.2 124.76,67.94 ; J10.2 123.11,68.66 ; J10.2 123.11,67.23 ; J10.2 123.83,67.01 ; J10.2 122.89,67.94 ; J10.2 124.54,67.23 ; J10.2 123.83,68.88 ; TP15.1 128.78,63.02 ; TP15.1 129.83,62.65 ; TP15.1 127.36,61.59 ; TP15.1 127.72,60.54 ; TP15.1 129.83,60.54 ; TP15.1 128.78,60.17 ; TP15.1 127.72,62.65 ; TP15.1 130.2,61.59
  vias: v1(119.13,48.39) v1(119.13,47.37) v1(119.13,46.1) v1(119.13,45.16) v1(119.53,47.88) v1(119.48,46.81) v1(119.89,45.09) v1(120.02,21.72) v1(121.03,48.51) v1(121.03,47.5) v1(121.03,46.23) v1(121.16,25.15) v1(121.16,22.86) v1(122.78,69.04) v1(122.86,67.03) v1(122.86,66.14) v1(123.65,65.15) v1(124.05,66.24) v1(124.94,66.85) v1(125.12,69.04) v1(125.12,65.86) v1(125.15,62.1) v1(126.42,62.13) v1(127.79,65.05) v1(127.79,63.37) v1(127.94,59.94) v1(128.35,64.39) v1(128.73,63.42) v1(128.93,65.05) v1(129.51,64.41) v1(129.64,24.84) v1(129.74,59.99) v1(129.67,23.11) v1(129.67,22.1) v1(129.67,20.83) v1(129.69,19.74) v1(129.79,63.47) v1(129.84,46.56) v1(129.87,48.54) v1(129.9,47.6) v1(129.92,45.59) v1(129.87,44.65) v1(129.97,65.05) v1(130.05,19.05) v1(130.18,49.02) v1(130.3,44.96) v1(130.81,49.02) v1(130.78,45.69) v1(130.76,23.19) v1(130.99,60.86) v1(131.62,45.54) v1(132.21,61.06)
5V_USB: length 33.7
  TOP w0.254: R3.2 96.62,55.22 101.35,59.94 103.38,59.94 TP8.1 ; R11.1 v1(103.63,44.96)
  TOP w0.381: C13.1 106.05,41.81 v1(106.4,41.81)
  TOP w0.508: U2.3 v1(108.27,40.2) ; v1(106.17,41.45) C13.1 105.83,42.1 U2.1
  LYR9-PWR w0.457: 102.45,59.01 TP8.1 ; TP8.1 104.56,59.01 ; TP8.1 104.93,60.07 ; TP8.1 102.45,61.13 ; TP8.1 103.5,58.65 ; TP8.1 104.56,61.13 ; TP8.1 102.08,60.07 ; TP8.1 103.5,61.49 ; J10.3 121.28,68.88 ; J10.3 120.57,68.66 ; J10.3 122.22,67.94 ; J10.3 121.28,67.01 ; J10.3 120.35,67.94 ; J10.3 120.57,67.23 ; J10.3 122,68.66 ; J10.3 122,67.23
GND: length 1373
  TOP w0.152: v1(46.44,40.92) 46.84,40.52 U9.F9 ; U9.D1 v1(40.04,42.52) ; U9.J16 v1(52.84,38.52)
  TOP w0.254: v1(95.76,50.55) 95.98,50.32 U4.5 ; v1(132.66,55.06) U15.6 ; U9.M15 v1(52.04,35.32) ; U9.E8 46.04,41.32 v1(45.64,41.72) ; v1(133.78,28.65) 133.31,28.65 v1(133.31,28.28) ; v1(48.84,42.52) 48.44,42.12 U9.D11 ; U9.P1 40.47,34.12 v1(40.77,34.42) ; Y1.2 103.33,55.04 v1(104.01,54.36) ; U9.J12 v1(49.64,38.52) ; 132.96,12.84 U14.7 v1(132.96,15.04) ; U9.H7 v1(44.84,39.32) ; U9.L8 v1(45.64,36.12) ; U9.N12 v1(49.64,34.52) ; U9.M11 48.44,35.72 v1(48.84,35.32) ; U4.47 v1(97.48,39.19) ; U9.G12 v1(49.64,40.12) ; v1(46.44,35.32) 46.84,35.72 U9.M9 ; U4.35 v1(91.48,39.45) ; U9.E14 50.84,41.32 v1(51.24,41.72) ; U7.8 v1(98.29,33.64) ; U3.32 v1(77.19,43.96) ; v1(103,43.81) v1(103.63,43.81) ; U3.5 v1(81.84,39.16) ; U9.U10 v1(48.04,31.32) ; U3.17 v1(79.4,43.96) ; U9.V13 v1(50.44,30.52) ; U9.J9 v1(46.44,38.52) ; U9.H9 v1(46.44,39.32) ; v1(44.84,40.92) 45.24,40.52 U9.F7 ; U9.R14 50.84,33.32 v1(51.24,32.92) ; U9.N8 46.04,34.92 v1(45.64,34.52) ; U9.M5 v1(43.24,35.32) ; U9.B15 v1(52.04,44.12) ; U9.L2 v1(40.84,36.12) ; C24.2 v1(68.71,41.02) ; U9.H3 v1(41.64,39.32) ; U9.A2 41.24,45.61 41.16,45.61 41.16,46.09 v1(41.15,46.1) ; U4.13 v1(91.98,47.72) ; U9.T17 v1(53.64,32.12) ; U9.K7 v1(44.84,36.92) ; v1(99.69,53.85) 100.48,54.63 Y1.4 ; U4.10 v1(93.48,46.98) ; v1(77.8,40.39) 77.12,40.39 77.1,40.36 U3.41 ; U9.C8 46.04,42.92 v1(45.64,43.32) ; v1(48.04,34.52) 47.64,34.92 U9.N10 ; U6.3 v1(68.31,37.7) ; U9.K11 v1(48.84,36.92) ; U9.H13 v1(50.44,39.32) ; v1(48.84,40.92) 48.44,40.52 U9.F11 ; U4.51 v1(101.26,40.68) ; U12.2 v1(121.67,37.08) ; U4.11 v1(92.98,47.61) ; C23.2 v1(64.9,37.97) ; v1(132.66,28.28) 132.66,29.15 v1(132.97,29.46) ; v1(122.67,15.5) U17.7 122.67,17.56 v1(122.63,17.6) ; U9.R4 v1(42.44,32.92) ; U9.M7 45.24,35.72 v1(44.84,35.32) ; v1(124.66,39.04) 124.84,38.86 v1(124.84,38.46) 125.17,38.46 v1(125.45,38.73) ; U11.6 122.37,55.06 v1(122.68,55.37) ; U9.C18 v1(56.76,42.92) ; U3.6 v1(82.24,39.56) ; U4.15 v1(90.98,50.49) ; U9.G10 v1(48.04,40.12) ; U9.V3 v1(42.04,30.49) ; U9.B5 v1(43.24,44.12) ; U9.E4 v1(42.44,41.72) ; U16.7 v1(132.96,38.36) ; C22.2 v1(64.77,39.5) ; U9.K10 v1(48.04,36.92) ; U9.L9 v1(46.44,36.12) ; U9.L12 v1(49.64,36.12) ; v1(122.67,40.04) v1(122.67,38.87) ; U9.A12 v1(49.24,44.93) ; U9.G8 v1(45.64,40.12) ; U3.4 v1(82.27,38.76) ; U9.L10 v1(48.04,36.12) ; v1(44.84,32.12) 45.24,32.52 U9.T7 ; U9.J6 v1(44.04,38.52) ; U9.F17 v1(53.64,40.92) ; U9.J8 v1(45.64,38.52) ; U9.H11 v1(48.84,39.32) ; U3.8 v1(79.4,40.36) ; v1(134.9,50.04) v1(134.34,50.04) ; v1(54.44,34.52) U9.N18 ; U3.7 v1(81.87,39.96) ; U4.1 v1(97.98,47.68)
  TOP w0.381: C111.2 135.48,38.2 ; 135.48,38.2 v1(135.74,38.46) ; 135.48,38.2 135.56,38.2 v1(135.74,38.02) ; v1(132.96,12.62) 132.96,12.84 ; C125.2 109.45,24.31 ; 109.45,24.31 v1(109.75,24.61) ; 109.45,24.31 109.45,24.51 v1(109.35,24.61) ; v1(111.51,52.58) 111.25,52.32 C20.2 ; 122.73,33.55 v1(123.22,33.07) ; 118.59,29.36 v1(118.21,28.98) ; 105.77,40.49 105.31,40.49 v1(105.21,40.59) ; 105.77,40.49 v1(105.21,41.05) ; 105.77,40.49 v1(105.79,40.49) ; v1(133.48,56.11) v1(133.48,56.69) ; C21.2 v1(102.11,58.29) ; 110.69,31.34 v1(111,31.65) ; 110.69,31.34 110.87,31.34 v1(110.97,31.24) ; 110.69,31.34 v1(110.36,31.34) ; v1(135.13,12.42) 135.48,12.42 ; 135.48,12.42 135.53,12.42 v1(135.71,12.6) ; 135.48,12.42 v1(135.71,12.19) ; v1(125.43,15.29) 125.22,15.09 v1(124.84,15.09) v1(124.84,15.67) ; 132.49,59.79 132.49,59.92 v1(132.64,60.07) ; 132.49,59.79 v1(132.21,60.07) ; 132.49,59.79 C108.2 132.18,59.44 v1(131.9,59.72) ; R52.2 123.19,56.79 v1(123.34,56.95) ; 130.15,57.68 129.92,57.68 v1(129.79,57.81) ; 130.15,57.68 v1(129.79,57.33) ; 130.15,57.68 C110.2 130.43,57.25 v1(130.28,57.1) ; 122.2,59.79 122.2,60.3 v1(122.17,60.33) ; 122.2,59.79 C95.2 ; 122.2,59.79 v1(121.69,60.3) ; v1(122.81,32.97) 122.56,33.22 v1(122.56,33.55) ; v1(119.53,58.09) 119.68,57.94 C98.2 v1(119.58,57.38) ; R18.2 v1(99.82,28.45) ; FB4.2 92.71,61.34 v1(92.74,61.37) J2.5 ; 120.62,33.55 v1(120.17,34.01) ; C19.2 v1(104.01,53.21) ; R23.1 v1(51.44,26.16) ; v1(132.33,33.05) 132.49,33.2 132.49,33.3 ; v1(118.87,29.36) 118.87,29.06 v1(118.59,28.78) ; 132.49,33.3 v1(132.74,33.05) ; 132.49,33.3 v1(132.49,33.66) ; v1(120.65,34.19) 120.78,34.06 v1(120.78,33.55) ; U4.25 v1(87,43.18) ; C25.2 v1(92.99,27.08) ; C18.2 v1(89.28,51.44) ; 123.34,56.36 v1(123.8,56.82)
  TOP w0.508: C125.2 v1(110.03,24.26) ; v1(124.84,38.46) v1(125.15,39.04) ; v1(129.79,31.9) v1(130.43,31.9) v1(130.43,32.51) ; v1(134.26,24.26) v1(134.9,24.26) v1(134.9,24.89) ; v1(135.13,12.42) v1(135.56,13) ; R40.2 v1(44.96,50.42) ; v1(134.11,30.33) v1(133.48,30.33) v1(133.48,30.94) ; v1(131.83,62.95) v1(131.83,61.72) ; v1(111.76,41.81) v1(111.76,41.17) ; C91.2 v1(123.83,60.58) ; C91.2 126.62,60.58 v1(127.25,59.94) ; C91.2 v1(125.35,58.29) ; v1(133.68,54.43) 133.31,54.43 U15.5 ; v1(110.36,31.34) v1(110.69,31.95) ; J3.1 v1(88.62,16.79) ; C126.2 v1(110.82,36.37) ; v1(105.46,31.05) v1(104.08,31.05) ; v1(123.34,33.55) v1(122.56,33.55) ; U18.7 v1(63.47,15.37) ; v1(120.78,33.55) v1(120.04,33.55) ; J3.3 v1(90.62,16.83) ; v1(116.81,50.29) v1(117.4,50.29) ; J3.7 v1(94.61,16.76) ; C111.2 v1(135.38,38.79) ; v1(132.49,33.66) v1(131.93,33.12) ; J3.9 v1(96.61,16.8) ; Y2.2 v1(66.55,53.85) ; v1(107.36,41.15) v1(108.2,41.15) ; U20.4 v1(107.61,20.49) ; C84.2 v1(67.44,48.13) ; R52.2 v1(123.85,56.36) ; R42.2 v1(40.51,50.42) ; J3.5 v1(92.62,16.8) ; v1(124.84,15.09) v1(125.25,15.67) ; C88.1 v1(41.66,52.45) ; J3.11 v1(98.61,16.83) ; U11.5 123.02,54.69 v1(123.49,54.69) ; v1(110.62,52.96) 110.85,52.73 110.85,52.68 ; C127.2 v1(118.62,18.16) ; v1(118.87,29.36) v1(117.96,29.36) ; v1(108.43,43.81) v1(109.04,44.12) ; C86.1 v1(46.1,52.45) ; v1(105.46,35.5) v1(104.08,35.5) ; C98.2 v1(120.14,57.25) ; v1(112.31,46.86) v1(113.54,46.86) ; C20.2 110.85,52.68 ; 110.85,52.68 v1(111.12,52.96) ; U1.2 v1(121.67,26.29) ; v1(105.79,40.49) v1(105.61,41.07) ; C16.2 v1(97.54,60.58) ; C95.2 v1(121.62,59.82) ; J3.13 v1(100.61,16.86) ; v1(105.46,36.45) v1(104.14,36.45) ; v1(124.61,50.29) v1(123.98,50.29)
  LY2-GND w0.432: 47.5,62.75 47.5,64.14 ; 47.5,64.14 48.53,65.16 ; 47.5,64.14 48.53,63.11 ; 47.5,64.14 46.11,64.14 ; 47.5,64.14 46.47,63.11 ; 47.5,64.14 47.5,65.52 ; 47.5,64.14 46.47,65.16 ; 47.5,64.14 48.88,64.14 ; J5.2 42.42,70.6 ; J5.2 41.39,70.24 ; J5.2 43.45,70.24 ; J5.2 41.03,69.22 ; J5.2 41.39,68.19 ; J5.2 43.8,69.22 ; J5.2 42.42,67.83 ; J5.2 43.45,68.19 ; 111.02,65.13 J4.2 ; J4.2 112.52,61.57 ; J4.2 111.02,62.12 ; J4.2 114.58,63.63 ; J4.2 110.46,63.63 ; J4.2 114.03,62.12 ; J4.2 112.52,65.68 ; J4.2 114.03,65.13 ; J11.6 100.37,11.22 ; J11.6 99.02,11.22 ; J11.6 100.37,9.86 ; J11.6 98.81,10.54 ; J11.6 100.58,10.54 ; J11.6 99.02,9.86 ; J11.6 99.69,11.43 ; J11.6 99.69,9.65 ; 104.78,9.65 J11.2 ; J11.2 103.89,10.54 ; J11.2 104.1,11.22 ; J11.2 104.78,11.43 ; J11.2 105.66,10.54 ; J11.2 105.45,11.22 ; J11.2 104.1,9.86 ; J11.2 105.45,9.86 ; J11.4 102.91,9.86 ; J11.4 102.23,9.65 ; J11.4 101.35,10.54 ; J11.4 102.23,11.43 ; J11.4 102.91,11.22 ; J11.4 103.12,10.54 ; J11.4 101.56,11.22 ; J11.4 101.56,9.86 ; 29.08,64.14 30.11,65.16 ; 29.08,64.14 29.08,65.52 ; 29.08,64.14 28.05,65.16 ; 29.08,64.14 27.7,64.14 ; 29.08,64.14 30.47,64.14 ; 29.08,64.14 28.05,63.11 ; 29.08,64.14 29.08,62.75 ; 29.08,64.14 30.11,63.11 ; J4.3 109.23,61.88 ; J4.3 109.23,58.87 ; J4.3 106.22,58.87 ; J4.3 105.66,60.38 ; J4.3 107.72,62.43 ; J4.3 106.22,61.88 ; J4.3 109.78,60.38 ; J4.3 107.72,58.32 ; 42.42,64.14 43.8,64.14 ; 42.42,64.14 41.03,64.14 ; 42.42,64.14 43.45,63.11 ; 42.42,64.14 41.39,65.16 ; 42.42,64.14 42.42,65.52 ; 42.42,64.14 42.42,62.75 ; 42.42,64.14 41.39,63.11 ; 42.42,64.14 43.45,65.16 ; J11.8 97.83,11.22 ; J11.8 97.16,9.65 ; J11.8 96.48,11.22 ; J11.8 97.16,11.43 ; J11.8 97.83,9.86 ; J11.8 96.48,9.86 ; J11.8 96.27,10.54 ; J11.8 98.04,10.54 ; 55.75,64.14 56.78,63.11 ; 55.75,64.14 54.72,63.11 ; 55.75,64.14 54.72,65.16 ; 55.75,64.14 54.37,64.14 ; 55.75,64.14 55.75,65.52 ; 55.75,64.14 56.78,65.16 ; 55.75,64.14 55.75,62.75 ; 55.75,64.14 57.14,64.14 ; TP2.1 74.34,11.72 ; TP2.1 73.28,9.25 ; TP2.1 74.7,10.67 ; TP2.1 74.34,9.61 ; TP2.1 72.22,9.61 ; TP2.1 72.22,11.72 ; TP2.1 71.86,10.67 ; TP2.1 73.28,12.09 ; J6.3 35.55,69.22 ; J6.3 35.19,70.24 ; J6.3 33.13,68.19 ; J6.3 33.13,70.24 ; J6.3 32.78,69.22 ; J6.3 34.16,70.6 ; J6.3 34.16,67.83 ; J6.3 35.19,68.19 ; 60.83,64.14 61.86,65.16 ; 60.83,64.14 62.22,64.14 ; 60.83,64.14 60.83,65.52 ; 60.83,64.14 59.8,65.16 ; 60.83,64.14 61.86,63.11 ; 60.83,64.14 59.45,64.14 ; 60.83,64.14 59.8,63.11 ; 60.83,64.14 60.83,62.75 ; SW1.1 63.09,54.97 ; SW1.1 61.93,53.8 ; SW1.1 62.22,52.92 ; SW1.1 62.22,54.67 ; SW1.1 63.97,52.92 ; SW1.1 63.09,52.63 ; SW1.1 63.97,54.67 ; SW1.1 64.26,53.8 ; J7.3 75.2,70.24 ; J7.3 75.55,69.22 ; J7.3 72.78,69.22 ; J7.3 74.17,70.6 ; J7.3 74.17,67.83 ; J7.3 75.2,68.19 ; J7.3 73.14,70.24 ; J7.3 73.14,68.19 ; TP3.1 115.19,39.4 ; TP3.1 114.13,36.92 ; TP3.1 116.25,36.92 ; TP3.1 115.19,36.55 ; TP3.1 114.13,39.03 ; TP3.1 116.25,39.03 ; TP3.1 113.77,37.97 ; TP3.1 116.61,37.97 ; 78.83,66.13 TP1.1 ; TP1.1 78.46,67.18 ; TP1.1 79.88,65.76 ; TP1.1 80.94,66.13 ; TP1.1 80.94,68.24 ; TP1.1 78.83,68.24 ; TP1.1 81.31,67.18 ; TP1.1 79.88,68.61 ; 59.8,70.24 J8.3 ; J8.3 59.45,69.22 ; J8.3 61.86,68.19 ; J8.3 60.83,67.83 ; J8.3 62.22,69.22 ; J8.3 60.83,70.6 ; J8.3 61.86,70.24 ; J8.3 59.8,68.19 ; 34.16,64.14 34.16,65.52 ; 34.16,64.14 35.55,64.14 ; 34.16,64.14 33.13,65.16 ; 34.16,64.14 35.19,63.11 ; 34.16,64.14 32.78,64.14 ; 34.16,64.14 35.19,65.16 ; 34.16,64.14 33.13,63.11 ; 34.16,64.14 34.16,62.75 ; J8.2 56.78,68.19 ; J8.2 55.75,67.83 ; J8.2 54.72,70.24 ; J8.2 54.37,69.22 ; J8.2 56.78,70.24 ; J8.2 57.14,69.22 ; J8.2 54.72,68.19 ; J8.2 55.75,70.6 ; J6.2 30.11,70.24 ; J6.2 30.11,68.19 ; J6.2 29.08,67.83 ; J6.2 28.05,68.19 ; J6.2 27.7,69.22 ; J6.2 30.47,69.22 ; J6.2 28.05,70.24 ; J6.2 29.08,70.6 ; 67.7,64.14 69.09,64.14 ; 69.09,64.14 70.47,64.14 ; 69.09,64.14 69.09,62.75 ; 69.09,64.14 68.06,65.16 ; 69.09,64.14 70.12,63.11 ; 69.09,64.14 70.12,65.16 ; 69.09,64.14 69.09,65.52 ; 69.09,64.14 68.06,63.11 ; J5.3 48.53,70.24 ; J5.3 46.47,70.24 ; J5.3 48.88,69.22 ; J5.3 47.5,67.83 ; J5.3 47.5,70.6 ; J5.3 48.53,68.19 ; J5.3 46.47,68.19 ; J5.3 46.11,69.22 ; 68.06,70.24 J7.2 ; J7.2 67.7,69.22 ; J7.2 70.47,69.22 ; J7.2 69.09,70.6 ; J7.2 68.06,68.19 ; J7.2 69.09,67.83 ; J7.2 70.12,68.19 ; J7.2 70.12,70.24 ; 74.17,62.75 74.17,64.14 ; 74.17,64.14 73.14,63.11 ; 74.17,64.14 74.17,65.52 ; 74.17,64.14 73.14,65.16 ; 74.17,64.14 75.2,65.16 ; 74.17,64.14 72.78,64.14 ; 74.17,64.14 75.55,64.14 ; 74.17,64.14 75.2,63.11
  LY4-GND w0.432: 60.83,64.14 61.86,65.16 ; 60.83,64.14 62.22,64.14 ; 60.83,64.14 59.8,65.16 ; 60.83,64.14 60.83,65.52 ; 60.83,64.14 60.83,62.75 ; 60.83,64.14 59.45,64.14 ; 60.83,64.14 59.8,63.11 ; 60.83,64.14 61.86,63.11 ; 41.39,68.19 J5.2 ; J5.2 41.03,69.22 ; J5.2 43.8,69.22 ; J5.2 43.45,70.24 ; J5.2 43.45,68.19 ; J5.2 42.42,70.6 ; J5.2 41.39,70.24 ; J5.2 42.42,67.83 ; 29.08,64.14 30.11,65.16 ; 29.08,64.14 30.11,63.11 ; 29.08,64.14 29.08,65.52 ; 29.08,64.14 28.05,65.16 ; 29.08,64.14 29.08,62.75 ; 29.08,64.14 28.05,63.11 ; 29.08,64.14 27.7,64.14 ; 29.08,64.14 30.47,64.14 ; 68.06,65.16 69.09,64.14 ; 69.09,64.14 70.47,64.14 ; 69.09,64.14 67.7,64.14 ; 69.09,64.14 69.09,65.52 ; 69.09,64.14 70.12,65.16 ; 69.09,64.14 68.06,63.11 ; 69.09,64.14 70.12,63.11 ; 69.09,64.14 69.09,62.75 ; 28.05,70.24 J6.2 ; J6.2 29.08,67.83 ; J6.2 29.08,70.6 ; J6.2 30.11,68.19 ; J6.2 27.7,69.22 ; J6.2 28.05,68.19 ; J6.2 30.11,70.24 ; J6.2 30.47,69.22 ; J5.3 48.88,69.22 ; J5.3 47.5,67.83 ; J5.3 47.5,70.6 ; J5.3 46.11,69.22 ; J5.3 48.53,70.24 ; J5.3 46.47,68.19 ; J5.3 48.53,68.19 ; J5.3 46.47,70.24 ; 74.17,64.14 75.2,63.11 ; 74.17,64.14 72.78,64.14 ; 74.17,64.14 75.2,65.16 ; 74.17,64.14 74.17,62.75 ; 74.17,64.14 73.14,63.11 ; 74.17,64.14 74.17,65.52 ; 74.17,64.14 75.55,64.14 ; 74.17,64.14 73.14,65.16 ; TP2.1 74.7,10.67 ; TP2.1 72.22,11.72 ; TP2.1 74.34,9.61 ; TP2.1 73.28,12.09 ; TP2.1 72.22,9.61 ; TP2.1 74.34,11.72 ; TP2.1 73.28,9.25 ; TP2.1 71.86,10.67 ; 104.78,9.65 J11.2 ; J11.2 105.45,9.86 ; J11.2 105.66,10.54 ; J11.2 104.1,9.86 ; J11.2 104.1,11.22 ; J11.2 103.89,10.54 ; J11.2 105.45,11.22 ; J11.2 104.78,11.43 ; J6.3 35.19,68.19 ; J6.3 35.19,70.24 ; J6.3 33.13,70.24 ; J6.3 32.78,69.22 ; J6.3 35.55,69.22 ; J6.3 34.16,67.83 ; J6.3 34.16,70.6 ; J6.3 33.13,68.19 ; J7.3 75.55,69.22 ; J7.3 75.2,68.19 ; J7.3 74.17,70.6 ; J7.3 73.14,70.24 ; J7.3 74.17,67.83 ; J7.3 75.2,70.24 ; J7.3 73.14,68.19 ; J7.3 72.78,69.22 ; 33.13,65.16 34.16,64.14 ; 34.16,64.14 35.19,65.16 ; 34.16,64.14 32.78,64.14 ; 34.16,64.14 34.16,65.52 ; 34.16,64.14 35.55,64.14 ; 34.16,64.14 35.19,63.11 ; 34.16,64.14 33.13,63.11 ; 34.16,64.14 34.16,62.75 ; 68.06,70.24 J7.2 ; J7.2 69.09,70.6 ; J7.2 67.7,69.22 ; J7.2 70.47,69.22 ; J7.2 69.09,67.83 ; J7.2 70.12,68.19 ; J7.2 68.06,68.19 ; J7.2 70.12,70.24 ; 41.03,64.14 42.42,64.14 ; 42.42,64.14 42.42,62.75 ; 42.42,64.14 42.42,65.52 ; 42.42,64.14 43.45,65.16 ; 42.42,64.14 43.8,64.14 ; 42.42,64.14 41.39,63.11 ; 42.42,64.14 43.45,63.11 ; 42.42,64.14 41.39,65.16 ; SW1.1 63.97,52.92 ; SW1.1 63.09,54.97 ; SW1.1 63.09,52.63 ; SW1.1 64.26,53.8 ; SW1.1 61.93,53.8 ; SW1.1 63.97,54.67 ; SW1.1 62.22,52.92 ; SW1.1 62.22,54.67 ; 47.5,64.14 48.53,63.11 ; 47.5,64.14 47.5,62.75 ; 47.5,64.14 47.5,65.52 ; 47.5,64.14 46.47,65.16 ; 47.5,64.14 48.53,65.16 ; 47.5,64.14 46.47,63.11 ; 47.5,64.14 48.88,64.14 ; 47.5,64.14 46.11,64.14 ; J8.2 57.14,69.22 ; J8.2 54.37,69.22 ; J8.2 56.78,70.24 ; J8.2 54.72,70.24 ; J8.2 55.75,67.83 ; J8.2 56.78,68.19 ; J8.2 54.72,68.19 ; J8.2 55.75,70.6 ; J4.2 114.03,62.12 ; J4.2 111.02,65.13 ; J4.2 112.52,65.68 ; J4.2 114.03,65.13 ; J4.2 112.52,61.57 ; J4.2 114.58,63.63 ; J4.2 111.02,62.12 ; J4.2 110.46,63.63 ; J11.6 100.37,11.22 ; J11.6 99.02,11.22 ; J11.6 100.58,10.54 ; J11.6 99.69,9.65 ; J11.6 99.69,11.43 ; J11.6 98.81,10.54 ; J11.6 100.37,9.86 ; J11.6 99.02,9.86 ; 54.72,63.11 55.75,64.14 ; 55.75,64.14 55.75,62.75 ; 55.75,64.14 54.37,64.14 ; 55.75,64.14 57.14,64.14 ; 55.75,64.14 55.75,65.52 ; 55.75,64.14 54.72,65.16 ; 55.75,64.14 56.78,63.11 ; 55.75,64.14 56.78,65.16 ; 105.66,60.38 J4.3 ; J4.3 109.23,58.87 ; J4.3 109.78,60.38 ; J4.3 107.72,62.43 ; J4.3 106.22,61.88 ; J4.3 107.72,58.32 ; J4.3 106.22,58.87 ; J4.3 109.23,61.88 ; 101.35,10.54 J11.4 ; J11.4 102.91,9.86 ; J11.4 102.23,9.65 ; J11.4 102.91,11.22 ; J11.4 101.56,11.22 ; J11.4 103.12,10.54 ; J11.4 102.23,11.43 ; J11.4 101.56,9.86 ; 60.83,67.83 J8.3 ; J8.3 62.22,69.22 ; J8.3 59.8,70.24 ; J8.3 60.83,70.6 ; J8.3 59.8,68.19 ; J8.3 61.86,70.24 ; J8.3 59.45,69.22 ; J8.3 61.86,68.19 ; 114.13,39.03 TP3.1 ; TP3.1 116.25,36.92 ; TP3.1 116.61,37.97 ; TP3.1 116.25,39.03 ; TP3.1 113.77,37.97 ; TP3.1 115.19,36.55 ; TP3.1 115.19,39.4 ; TP3.1 114.13,36.92 ; J11.8 98.04,10.54 ; J11.8 96.48,9.86 ; J11.8 96.48,11.22 ; J11.8 97.83,11.22 ; J11.8 97.16,9.65 ; J11.8 96.27,10.54 ; J11.8 97.83,9.86 ; J11.8 97.16,11.43 ; TP1.1 81.31,67.18 ; TP1.1 80.94,68.24 ; TP1.1 78.83,68.24 ; TP1.1 79.88,68.61 ; TP1.1 78.83,66.13 ; TP1.1 80.94,66.13 ; TP1.1 79.88,65.76 ; TP1.1 78.46,67.18
  LY6-GND w0.432: 29.08,64.14 30.11,63.11 ; 29.08,64.14 28.05,63.11 ; 29.08,64.14 30.11,65.16 ; 29.08,64.14 30.47,64.14 ; 29.08,64.14 27.7,64.14 ; 29.08,64.14 28.05,65.16 ; 29.08,64.14 29.08,65.52 ; 29.08,64.14 29.08,62.75 ; 41.39,65.16 42.42,64.14 ; 42.42,64.14 41.03,64.14 ; 42.42,64.14 42.42,62.75 ; 42.42,64.14 41.39,63.11 ; 42.42,64.14 43.45,65.16 ; 42.42,64.14 43.45,63.11 ; 42.42,64.14 42.42,65.52 ; 42.42,64.14 43.8,64.14 ; J11.4 102.23,11.43 ; J11.4 101.56,11.22 ; J11.4 101.56,9.86 ; J11.4 102.23,9.65 ; J11.4 102.91,11.22 ; J11.4 102.91,9.86 ; J11.4 103.12,10.54 ; J11.4 101.35,10.54 ; 99.02,9.86 J11.6 ; J11.6 98.81,10.54 ; J11.6 99.69,9.65 ; J11.6 99.02,11.22 ; J11.6 100.37,9.86 ; J11.6 100.37,11.22 ; J11.6 100.58,10.54 ; J11.6 99.69,11.43 ; 55.75,64.14 56.78,63.11 ; 55.75,64.14 55.75,62.75 ; 55.75,64.14 55.75,65.52 ; 55.75,64.14 56.78,65.16 ; 55.75,64.14 57.14,64.14 ; 55.75,64.14 54.37,64.14 ; 55.75,64.14 54.72,63.11 ; 55.75,64.14 54.72,65.16 ; 54.37,69.22 J8.2 ; J8.2 57.14,69.22 ; J8.2 55.75,70.6 ; J8.2 55.75,67.83 ; J8.2 56.78,68.19 ; J8.2 54.72,70.24 ; J8.2 54.72,68.19 ; J8.2 56.78,70.24 ; 110.46,63.63 J4.2 ; J4.2 114.03,65.13 ; J4.2 112.52,61.57 ; J4.2 114.58,63.63 ; J4.2 111.02,62.12 ; J4.2 111.02,65.13 ; J4.2 114.03,62.12 ; J4.2 112.52,65.68 ; 69.09,64.14 70.12,65.16 ; 69.09,64.14 67.7,64.14 ; 69.09,64.14 70.12,63.11 ; 69.09,64.14 70.47,64.14 ; 69.09,64.14 68.06,65.16 ; 69.09,64.14 69.09,62.75 ; 69.09,64.14 68.06,63.11 ; 69.09,64.14 69.09,65.52 ; J8.3 60.83,70.6 ; J8.3 59.8,68.19 ; J8.3 60.83,67.83 ; J8.3 61.86,68.19 ; J8.3 59.8,70.24 ; J8.3 61.86,70.24 ; J8.3 59.45,69.22 ; J8.3 62.22,69.22 ; 114.13,39.03 TP3.1 ; TP3.1 113.77,37.97 ; TP3.1 114.13,36.92 ; TP3.1 116.25,36.92 ; TP3.1 115.19,36.55 ; TP3.1 115.19,39.4 ; TP3.1 116.25,39.03 ; TP3.1 116.61,37.97 ; J11.8 97.16,11.43 ; J11.8 96.48,9.86 ; J11.8 98.04,10.54 ; J11.8 96.48,11.22 ; J11.8 97.16,9.65 ; J11.8 97.83,11.22 ; J11.8 97.83,9.86 ; J11.8 96.27,10.54 ; J7.3 75.2,70.24 ; J7.3 74.17,67.83 ; J7.3 75.2,68.19 ; J7.3 73.14,68.19 ; J7.3 72.78,69.22 ; J7.3 73.14,70.24 ; J7.3 74.17,70.6 ; J7.3 75.55,69.22 ; 46.47,63.11 47.5,64.14 ; 47.5,64.14 48.88,64.14 ; 47.5,64.14 47.5,62.75 ; 47.5,64.14 46.11,64.14 ; 47.5,64.14 48.53,65.16 ; 47.5,64.14 48.53,63.11 ; 47.5,64.14 46.47,65.16 ; 47.5,64.14 47.5,65.52 ; 33.13,63.11 34.16,64.14 ; 34.16,64.14 34.16,65.52 ; 34.16,64.14 35.19,63.11 ; 34.16,64.14 35.19,65.16 ; 34.16,64.14 33.13,65.16 ; 34.16,64.14 32.78,64.14 ; 34.16,64.14 35.55,64.14 ; 34.16,64.14 34.16,62.75 ; 73.14,65.16 74.17,64.14 ; 74.17,64.14 74.17,62.75 ; 74.17,64.14 75.55,64.14 ; 74.17,64.14 72.78,64.14 ; 74.17,64.14 75.2,65.16 ; 74.17,64.14 75.2,63.11 ; 74.17,64.14 74.17,65.52 ; 74.17,64.14 73.14,63.11 ; 72.22,9.61 TP2.1 ; TP2.1 74.34,11.72 ; TP2.1 72.22,11.72 ; TP2.1 71.86,10.67 ; TP2.1 74.34,9.61 ; TP2.1 73.28,9.25 ; TP2.1 74.7,10.67 ; TP2.1 73.28,12.09 ; J7.2 69.09,70.6 ; J7.2 68.06,70.24 ; J7.2 67.7,69.22 ; J7.2 70.12,68.19 ; J7.2 70.12,70.24 ; J7.2 69.09,67.83 ; J7.2 70.47,69.22 ; J7.2 68.06,68.19 ; 106.22,61.88 J4.3 ; J4.3 107.72,62.43 ; J4.3 107.72,58.32 ; J4.3 109.23,58.87 ; J4.3 109.78,60.38 ; J4.3 105.66,60.38 ; J4.3 109.23,61.88 ; J4.3 106.22,58.87 ; J6.3 34.16,70.6 ; J6.3 35.55,69.22 ; J6.3 33.13,68.19 ; J6.3 33.13,70.24 ; J6.3 35.19,68.19 ; J6.3 34.16,67.83 ; J6.3 35.19,70.24 ; J6.3 32.78,69.22 ; J6.2 30.11,70.24 ; J6.2 30.47,69.22 ; J6.2 29.08,67.83 ; J6.2 29.08,70.6 ; J6.2 30.11,68.19 ; J6.2 28.05,68.19 ; J6.2 27.7,69.22 ; J6.2 28.05,70.24 ; 59.8,65.16 60.83,64.14 ; 60.83,64.14 59.45,64.14 ; 60.83,64.14 60.83,62.75 ; 60.83,64.14 61.86,63.11 ; 60.83,64.14 61.86,65.16 ; 60.83,64.14 59.8,63.11 ; 60.83,64.14 62.22,64.14 ; 60.83,64.14 60.83,65.52 ; 104.1,9.86 J11.2 ; J11.2 105.66,10.54 ; J11.2 104.1,11.22 ; J11.2 104.78,9.65 ; J11.2 105.45,9.86 ; J11.2 105.45,11.22 ; J11.2 104.78,11.43 ; J11.2 103.89,10.54 ; SW1.1 63.97,54.67 ; SW1.1 63.09,54.97 ; SW1.1 62.22,54.67 ; SW1.1 62.22,52.92 ; SW1.1 61.93,53.8 ; SW1.1 63.97,52.92 ; SW1.1 64.26,53.8 ; SW1.1 63.09,52.63 ; J5.3 48.53,68.19 ; J5.3 46.47,68.19 ; J5.3 46.11,69.22 ; J5.3 48.88,69.22 ; J5.3 47.5,67.83 ; J5.3 48.53,70.24 ; J5.3 47.5,70.6 ; J5.3 46.47,70.24 ; 41.39,70.24 J5.2 ; J5.2 41.03,69.22 ; J5.2 42.42,70.6 ; J5.2 43.45,70.24 ; J5.2 42.42,67.83 ; J5.2 43.8,69.22 ; J5.2 43.45,68.19 ; J5.2 41.39,68.19 ; TP1.1 80.94,66.13 ; TP1.1 80.94,68.24 ; TP1.1 78.83,68.24 ; TP1.1 79.88,68.61 ; TP1.1 79.88,65.76 ; TP1.1 78.46,67.18 ; TP1.1 81.31,67.18 ; TP1.1 78.83,66.13
  LYR8-GND w0.457: 54.72,68.19 J8.2 ; J8.2 55.75,70.6 ; J8.2 54.37,69.22 ; J8.2 57.14,69.22 ; J8.2 56.78,68.19 ; J8.2 55.75,67.83 ; J8.2 54.72,70.24 ; J8.2 56.78,70.24 ; 29.08,64.14 30.47,64.14 ; 29.08,64.14 30.11,65.16 ; 29.08,64.14 29.08,62.75 ; 29.08,64.14 27.7,64.14 ; 29.08,64.14 28.05,63.11 ; 29.08,64.14 28.05,65.16 ; 29.08,64.14 30.11,63.11 ; 29.08,64.14 29.08,65.52 ; 73.14,63.11 74.17,64.14 ; 74.17,64.14 75.2,65.16 ; 74.17,64.14 75.55,64.14 ; 74.17,64.14 74.17,65.52 ; 74.17,64.14 73.14,65.16 ; 74.17,64.14 74.17,62.75 ; 74.17,64.14 75.2,63.11 ; 74.17,64.14 72.78,64.14 ; TP3.1 116.61,37.97 ; TP3.1 114.13,36.92 ; TP3.1 115.19,39.4 ; TP3.1 114.13,39.03 ; TP3.1 116.25,36.92 ; TP3.1 116.25,39.03 ; TP3.1 115.19,36.55 ; TP3.1 113.77,37.97 ; 96.48,11.22 J11.8 ; J11.8 97.16,9.65 ; J11.8 97.83,9.86 ; J11.8 96.48,9.86 ; J11.8 97.83,11.22 ; J11.8 98.04,10.54 ; J11.8 97.16,11.43 ; J11.8 96.27,10.54 ; 60.83,67.83 J8.3 ; J8.3 59.8,70.24 ; J8.3 60.83,70.6 ; J8.3 59.45,69.22 ; J8.3 59.8,68.19 ; J8.3 62.22,69.22 ; J8.3 61.86,68.19 ; J8.3 61.86,70.24 ; 101.56,9.86 J11.4 ; J11.4 102.23,9.65 ; J11.4 101.35,10.54 ; J11.4 102.23,11.43 ; J11.4 101.56,11.22 ; J11.4 102.91,9.86 ; J11.4 102.91,11.22 ; J11.4 103.12,10.54 ; 33.13,65.16 34.16,64.14 ; 34.16,64.14 34.16,62.75 ; 34.16,64.14 35.19,63.11 ; 34.16,64.14 32.78,64.14 ; 34.16,64.14 33.13,63.11 ; 34.16,64.14 35.19,65.16 ; 34.16,64.14 34.16,65.52 ; 34.16,64.14 35.55,64.14 ; 41.03,64.14 42.42,64.14 ; 42.42,64.14 42.42,65.52 ; 42.42,64.14 42.42,62.75 ; 42.42,64.14 43.45,63.11 ; 42.42,64.14 41.39,65.16 ; 42.42,64.14 43.45,65.16 ; 42.42,64.14 43.8,64.14 ; 42.42,64.14 41.39,63.11 ; J7.2 70.47,69.22 ; J7.2 69.09,70.6 ; J7.2 70.12,68.19 ; J7.2 68.06,68.19 ; J7.2 68.06,70.24 ; J7.2 69.09,67.83 ; J7.2 67.7,69.22 ; J7.2 70.12,70.24 ; 55.75,64.14 56.78,65.16 ; 55.75,64.14 54.37,64.14 ; 55.75,64.14 54.72,65.16 ; 55.75,64.14 56.78,63.11 ; 55.75,64.14 55.75,62.75 ; 55.75,64.14 54.72,63.11 ; 55.75,64.14 57.14,64.14 ; 55.75,64.14 55.75,65.52 ; J4.2 114.03,62.12 ; J4.2 111.02,65.13 ; J4.2 114.58,63.63 ; J4.2 110.46,63.63 ; J4.2 112.52,65.68 ; J4.2 112.52,61.57 ; J4.2 114.03,65.13 ; J4.2 111.02,62.12 ; 33.13,68.19 J6.3 ; J6.3 35.19,70.24 ; J6.3 35.19,68.19 ; J6.3 35.55,69.22 ; J6.3 34.16,70.6 ; J6.3 34.16,67.83 ; J6.3 32.78,69.22 ; J6.3 33.13,70.24 ; 59.8,65.16 60.83,64.14 ; 60.83,64.14 61.86,65.16 ; 60.83,64.14 62.22,64.14 ; 60.83,64.14 59.45,64.14 ; 60.83,64.14 60.83,65.52 ; 60.83,64.14 59.8,63.11 ; 60.83,64.14 60.83,62.75 ; 60.83,64.14 61.86,63.11 ; 73.14,68.19 J7.3 ; J7.3 73.14,70.24 ; J7.3 74.17,67.83 ; J7.3 75.55,69.22 ; J7.3 75.2,70.24 ; J7.3 75.2,68.19 ; J7.3 72.78,69.22 ; J7.3 74.17,70.6 ; 41.03,69.22 J5.2 ; J5.2 41.39,70.24 ; J5.2 42.42,67.83 ; J5.2 43.45,68.19 ; J5.2 43.8,69.22 ; J5.2 41.39,68.19 ; J5.2 43.45,70.24 ; J5.2 42.42,70.6 ; 47.5,62.75 47.5,64.14 ; 47.5,64.14 48.53,65.16 ; 47.5,64.14 46.11,64.14 ; 47.5,64.14 48.88,64.14 ; 47.5,64.14 48.53,63.11 ; 47.5,64.14 46.47,65.16 ; 47.5,64.14 47.5,65.52 ; 47.5,64.14 46.47,63.11 ; TP1.1 80.94,66.13 ; TP1.1 79.88,68.61 ; TP1.1 78.83,68.24 ; TP1.1 78.83,66.13 ; TP1.1 80.94,68.24 ; TP1.1 79.88,65.76 ; TP1.1 78.46,67.18 ; TP1.1 81.31,67.18 ; 99.69,9.65 J11.6 ; J11.6 98.81,10.54 ; J11.6 99.02,11.22 ; J11.6 100.37,11.22 ; J11.6 100.37,9.86 ; J11.6 99.69,11.43 ; J11.6 100.58,10.54 ; J11.6 99.02,9.86 ; TP2.1 74.34,9.61 ; TP2.1 74.34,11.72 ; TP2.1 71.86,10.67 ; TP2.1 73.28,9.25 ; TP2.1 72.22,11.72 ; TP2.1 73.28,12.09 ; TP2.1 72.22,9.61 ; TP2.1 74.7,10.67 ; 68.06,65.16 69.09,64.14 ; 69.09,64.14 68.06,63.11 ; 69.09,64.14 69.09,62.75 ; 69.09,64.14 70.47,64.14 ; 69.09,64.14 67.7,64.14 ; 69.09,64.14 70.12,63.11 ; 69.09,64.14 70.12,65.16 ; 69.09,64.14 69.09,65.52 ; J11.2 105.66,10.54 ; J11.2 104.78,11.43 ; J11.2 104.1,9.86 ; J11.2 103.89,10.54 ; J11.2 105.45,9.86 ; J11.2 104.78,9.65 ; J11.2 104.1,11.22 ; J11.2 105.45,11.22 ; SW1.1 63.09,54.97 ; SW1.1 63.97,54.67 ; SW1.1 61.93,53.8 ; SW1.1 63.97,52.92 ; SW1.1 63.09,52.63 ; SW1.1 62.22,54.67 ; SW1.1 62.22,52.92 ; SW1.1 64.26,53.8 ; 29.08,67.83 J6.2 ; J6.2 28.05,68.19 ; J6.2 30.11,68.19 ; J6.2 29.08,70.6 ; J6.2 30.47,69.22 ; J6.2 30.11,70.24 ; J6.2 28.05,70.24 ; J6.2 27.7,69.22 ; 47.5,67.83 J5.3 ; J5.3 48.53,68.19 ; J5.3 46.47,68.19 ; J5.3 48.53,70.24 ; J5.3 46.11,69.22 ; J5.3 46.47,70.24 ; J5.3 47.5,70.6 ; J5.3 48.88,69.22 ; 107.72,58.32 J4.3 ; J4.3 105.66,60.38 ; J4.3 109.23,58.87 ; J4.3 107.72,62.43 ; J4.3 109.23,61.88 ; J4.3 106.22,58.87 ; J4.3 109.78,60.38 ; J4.3 106.22,61.88
  BOTTOM w0.152: v1(49.24,44.93) 49.21,44.96 C39.2
  BOTTOM w0.254: v1(46.44,40.92) 46.55,40.82 C83.2 ; C33.2 49.77,35.99 v1(49.64,36.12) ; R5.1 v1(95.5,45.72) ; C57.2 51.98,35.38 v1(52.04,35.32) ; C10.2 v1(95.76,43.18) ; v1(48.84,35.32) 48.78,35.38 C37.2 ; v1(50.44,39.32) 50.44,39.52 C34.2 ; v1(45.64,34.52) 45.67,34.49 C36.2 ; C49.2 50.44,30.66 v1(50.44,30.52) ; C78.2 44.15,38.42 v1(44.04,38.52) ; C76.2 47.92,35.99 v1(48.04,36.12) ; v1(49.38,48.23) C38.2 49.78,46.61 v1(50.16,46.99) ; C75.2 44.84,41.16 v1(44.84,40.92) ; C47.2 v1(38.1,40.89) ; C77.2 49.58,34.46 v1(49.64,34.52) ; C8.2 v1(94.87,42.16) ; v1(38.48,42.55) 38.86,42.16 C44.2 ; C68.2 v1(46.48,32.08) ; C32.2 v1(57.15,36.07) ; v1(53.64,32.12) 53.05,32.72 C56.2 ; v1(40.39,47.12) C40.2 v1(41.15,46.1) ; C28.2 46.49,39.37 v1(46.44,39.32) ; C71.2 48.08,40.16 v1(48.04,40.12) ; v1(46.44,35.32) 46.65,35.32 C82.2 ; C51.2 44.65,45.67 44.83,45.85 44.96,45.85 v1(45.09,45.97) ; C65.2 v1(53.67,46.02) ; v1(44.84,39.32) 44.72,39.45 C79.2 ; C48.2 v1(38.25,43.15) ; v1(40.77,34.42) 40.77,34.47 C50.2 ; C17.2 v1(78.46,43.79) ; C81.2 45.03,37.11 v1(44.84,36.92) ; C66.2 v1(55.55,39.62) ; C12.2 v1(98.93,49.28) ; C72.2 v1(45.64,36.12) ; C64.2 53.21,41.35 v1(53.64,40.92) ; v1(42.44,32.92) 42.42,32.89 C60.2 ; v1(49.64,40.12) 49.82,40.12 C31.2 ; v1(45.64,38.52) 45.81,38.52 C74.2 ; v1(92.98,47.61) 92.56,48.03 C2.2 ; C62.2 v1(48.9,43.31) ; C80.2 49.64,38.11 v1(49.64,38.52) ; v1(40.84,36.12) 41.48,36.75 C58.2 ; v1(48.84,40.92) 48.69,41.07 C73.2 ; C4.2 v1(88.52,49.02) ; v1(44.84,35.32) 44.63,35.1 C70.2 ; v1(91.95,51.56) 92.56,50.95 C1.2 ; C53.2 v1(44.96,29.84) ; C29.2 v1(51.94,29.08) ; C63.2 v1(50.42,40.13) ; C67.2 v1(52.07,36.96) ; C55.2 v1(54.31,29.79) ; C43.2 v1(52.53,29.79) ; C35.2 48.97,37.05 v1(48.84,36.92) ; C9.2 v1(92.96,40.26) ; C59.2 v1(55.8,32.84) ; C6.2 v1(101.24,48.54) ; C11.2 v1(92.84,45.72) ; C5.2 v1(90.65,39.34) ; C45.2 v1(43.31,29.34) ; C52.2 v1(38.1,38.1) ; C14.2 v1(98.93,50.8) ; C7.2 v1(104.27,39.75)
  BOTTOM w0.508: v1(58.04,41.27) C61.2 58.93,42.42 v1(59.18,42.67) ; C54.2 v1(59.44,30.99) ; C54.2 v1(58.42,32) ; C54.2 v1(58.42,29.97) ; v1(46.23,29.34) C69.2 46.89,27.97 v1(47.02,27.84) ; C118.2 v1(120.04,28.55) ; v1(58.42,39.12) C27.2 v1(59.44,37.59)
  vias: v1(38.18,49.78) v1(38.81,39.12) v1(41.73,47.62) v1(47.24,44.96) v1(48.77,51.05) v1(51.05,51.05) v1(108.18,44.45) v1(108.64,44.45) v1(110.95,35.97) v1(110.95,35.53) v1(121.3,53.21) v1(121.69,26.8) v1(122.05,53.21) v1(122.8,53.21) v1(124.84,45.09) v1(124.97,21.84) v1(125.98,48.51) v1(125.98,47.5) v1(125.98,46.23) v1(126.11,25.27) v1(126.11,24.26) v1(126.11,22.99) v1(130.05,32.26) v1(131.58,52.96) v1(131.58,27.18) v1(132.33,52.96) v1(132.33,27.18) v1(132.97,38.84) v1(133.08,52.96) v1(133.08,27.18) v1(133.86,30.73) v1(134.49,24.64) v1(135.25,45.59) v1(135.38,19.3) v1(135.51,49.02) v1(135.64,44.96) v1(136.14,49.02) v1(136.53,22.73) v1(136.53,21.72) v1(136.53,20.45) v2(5.21,58.88) v2(5.21,57.61) v2(5.21,53.8) v2(5.21,49.99) v2(5.21,46.18) v2(5.21,42.37) v2(5.21,38.56) v2(5.21,34.75) v2(5.21,30.94) v2(5.21,27.13) v2(5.21,23.32) v2(5.21,19.51) v2(5.21,15.7) v2(5.21,11.89) v2(6.48,60.15) v2(6.48,56.34) v2(6.48,55.07) v2(6.48,51.26) v2(6.48,47.45) v2(6.48,43.64) v2(6.48,39.83) v2(6.48,36.02) v2(6.48,32.21) v2(6.48,28.4) v2(6.48,24.59) v2(6.48,20.78) v2(6.48,16.97) v2(6.48,13.16) v2(6.48,10.62) v2(7.75,57.61) v2(7.75,53.8) v2(7.75,49.99) v2(7.75,46.18) v2(7.75,42.37) v2(7.75,38.56) v2(7.75,34.75) v2(7.75,30.94) v2(7.75,27.13) v2(7.75,23.32) v2(7.75,19.51) v2(7.75,15.7) v2(7.75,11.89) v2(9.02,60.15) v2(9.02,56.34) v2(9.02,55.07) v2(9.02,51.26) v2(9.02,47.45) v2(9.02,43.64) v2(9.02,39.83) v2(9.02,36.02) v2(9.02,32.21) v2(9.02,28.4) v2(9.02,24.59) v2(9.02,20.78) v2(9.02,16.97) v2(9.02,13.16) v2(9.02,10.62) v2(10.29,58.88) v2(10.29,57.61) v2(10.29,53.8) v2(10.29,49.99) v2(10.29,46.18) v2(10.29,42.37) v2(10.29,38.56) v2(10.29,34.75) v2(10.29,30.94) v2(10.29,27.13) v2(10.29,23.32) v2(10.29,19.51) v2(10.29,15.7) v2(10.29,11.89) v2(11.56,60.15) v2(11.56,56.34) v2(11.56,55.07) v2(11.56,51.26) v2(11.56,47.45) v2(11.56,43.64) v2(11.56,39.83) v2(11.56,36.02) v2(11.56,32.21) v2(11.56,28.4) v2(11.56,24.59) v2(11.56,20.78) v2(11.56,16.97) v2(11.56,13.16) v2(11.56,10.62) v2(12.83,58.88) v2(12.83,57.61) v2(12.83,53.8) v2(12.83,52.53) v2(12.83,48.72) v2(12.83,44.91) v2(12.83,41.1) v2(12.83,37.29) v2(12.83,33.48) v2(12.83,29.67) v2(12.83,25.86) v2(12.83,16.97) v2(12.83,14.43) v2(12.83,11.89) v2(14.1,60.15) v2(14.1,56.34) v2(14.1,55.07) v2(14.1,51.26) v2(14.1,49.99) v2(14.1,46.18) v2(14.1,44.91) v2(14.1,41.1) v2(14.1,39.83) v2(14.1,36.02) v2(14.1,34.75) v2(14.1,30.94) v2(14.1,29.67) v2(14.1,25.86) v2(14.1,24.59) v2(14.1,20.78) v2(14.1,19.51) v2(14.1,18.24) v2(14.1,15.7) v2(14.1,13.16) v2(14.1,10.62) v2(15.37,58.88) v2(15.37,57.61) v2(15.37,53.8) v2(15.37,52.53) v2(15.37,48.72) v2(15.37,47.45) v2(15.37,43.64) v2(15.37,42.37) v2(15.37,38.56) v2(15.37,37.29) v2(15.37,33.48) v2(15.37,32.21) v2(15.37,28.4) v2(15.37,27.13) v2(15.37,23.32) v2(15.37,22.05) v2(15.37,18.24) v2(15.37,16.97) v2(15.37,13.16) v2(15.37,11.89) v2(16.64,60.15) v2(16.64,56.34) v2(16.64,55.07) v2(16.64,51.26) v2(16.64,49.99) v2(16.64,46.18) v2(16.64,44.91) v2(16.64,41.1) v2(16.64,39.83) v2(16.64,36.02) v2(16.64,34.75) v2(16.64,30.94) v2(16.64,29.67) v2(16.64,25.86) v2(16.64,24.59) v2(16.64,20.78) v2(16.64,19.51) v2(16.64,15.7) v2(16.64,14.43) v2(16.64,10.62)
1P0V_SHUNTN: length 10.6
  TOP w0.254: C94.1 122.3,50.29 ; C94.1 123.02,50.31 U11.4 ; C94.1 R76.2 123.04,46.58 122.43,45.97 R54.1 ; 122.3,50.29 122.37,50.36 U11.3 ; 122.3,50.29 R49.1
1P8V_SHUNTN: length 9.2
  TOP w0.254: U13.4 133.32,26.06 C101.1 ; C101.1 132.66,24.92 U13.3 ; C101.1 R74.2 133.32,20.04 132.72,19.43 R60.1
2P5V_REG_EN: length 46.8
  TOP w0.127: R56.1 131.7,24.26 v1(131.06,24.89)
  TOP w0.254: v1(130.48,51.48) 131.36,51.48 U15.1 ; v1(131.06,24.89) 130.68,25.27 130.17,25.27 129.16,26.29 122.94,26.29 122.62,26.61 U1.3
  LY5-SIGNAL w0.127: v1(130.48,51.48) 130.48,50.24 131.95,48.77 131.95,45.73 131.99,45.69 131.99,45.39 131.95,45.36 131.95,45.34 136.53,40.77 136.53,27.3 134.75,25.53 131.57,25.53 131.06,25.02 v1(131.06,24.89)
  BOTTOM w0.127: R78.2 130.43,24.26 v1(131.06,24.89)
2P5V_SHUNTN: length 9.5
  TOP w0.254: R75.2 123.04,24.92 122.2,25.76 121.18,25.76 120.78,26.16 120.78,27.55 U1.1
  TOP w0.279: U1.1 120.53,27.79 C121.1 ; R75.2 123.04,22.48 R72.1
3P3V_SHUNTN: length 9.2
  TOP w0.254: C107.1 R73.2 132.72,46.63 R66.1 ; C107.1 133.32,51.84 U15.4 ; C107.1 132.66,50.7 U15.3
AC-CLK-IN: length 20.1
  TOP w0.279: J6.1 31.62,60.07 39.37,52.32 C87.1
AC_CLK: length 10.5
  TOP w0.127: U9.B8 46.04,43.96 46.44,44.36 46.44,44.68 45.72,45.4 45.72,46.35 45.21,46.86 45.21,47.12 44.45,47.88 42.8,47.88 R41.2
  TOP w0.279: C87.2 R42.1 R41.2
ALIVE: length 40.9
  TOP w0.127: U18.11 71.37,19.18 71.75,19.56 71.75,24.6 62.2,34.16 v1(59.31,34.16)
  TOP w0.152: v1(59.31,34.16) 58.8,34.16 R91.2 ; U9.D12 49.24,42.12 v1(49.64,42.52)
  BOTTOM w0.152: v1(49.64,42.52) 51.92,42.52 52.32,42.93 53.85,42.93 54.1,42.67 54.1,41.15 54.61,40.64 56.06,40.64 57.18,39.52 57.18,37.06 58.8,35.43 58.8,34.67 v1(59.31,34.16)
BB_RDSTBN: length 26.9
  TOP w0.152: U4.53 v1(98.07,41.68) ; U3.2 v1(78.37,37.96)
  LY5-SIGNAL w0.127: 79.63,41.68 v1(98.07,41.68)
  LY5-SIGNAL w0.152: v1(78.37,37.96) 78.37,40.42 79.63,41.68
BB_WRSTBN: length 23.9
  TOP w0.152: v1(97.17,41.26) 97.25,41.18 U4.52 ; U3.3 v1(79.13,38.36)
  LY5-SIGNAL w0.127: v1(97.17,41.26) 81.53,41.26
  LY5-SIGNAL w0.152: v1(79.13,38.36) 79.13,38.86 81.53,41.26
BS_ENA: length 14.9
  TOP w0.152: 80.39,32 79.12,33.28 v1(79.12,33.4) ; v1(74.55,37.96) U3.47 ; v1(74.55,37.96) 74.55,37.72 74.7,37.56 U3.48 ; v1(74.55,37.96) 73.91,37.96 73.66,37.72 R27.2 72.63,37.7 U6.4
  LY5-SIGNAL w0.152: v1(79.12,33.4) v1(74.55,37.96)
D0_TCK_SCLK: length 8.9
  TOP w0.152: U7.12 90.48,31.69 90.04,32.13 90.04,34.04 90.81,34.8 91.57,34.8 92.96,36.2 92.96,37.79 U4.38
D1_TDI_MOSI: length 5.6
  TOP w0.152: U4.39 93.48,34.68 92.46,33.66 91.42,33.66 U7.9
D2_TDO_MISO: length 7.3
  TOP w0.152: U7.7 95.02,32.99 93.98,34.04 93.98,37.81 U4.40
D3_TMS_SEN: length 12.3
  TOP w0.127: U7.4 98.1,31.04 98.3,31.24 99.06,31.24 99.31,31.5 99.31,33.66 98.17,34.8 95.5,34.8 94.48,35.82 U4.41
DCLK_N: length 53.2
  TOP w0.152: U9.D3 v1(41.64,42.52)
  LY3-SIGNAL w0.127: v2(10.29,55.07) 10.76,55.54 23.82,55.54 24.14,55.86 24.14,55.98 24.26,56.11 24.44,56.11 24.57,55.98 24.57,55.29 24.89,54.97 25.34,54.97 25.66,55.29 25.66,55.98 25.79,56.11 25.97,56.11 26.09,55.98 26.09,55.29 26.41,54.97 26.86,54.97 27.18,55.29 27.18,55.98 27.31,56.11 27.49,56.11 27.62,55.98 27.62,55.29 27.94,54.97 28.39,54.97 28.71,55.29 28.71,55.98 28.83,56.11 29.01,56.11 29.14,55.98 29.14,55.29 29.46,54.97 29.91,54.97 30.23,55.29 30.23,55.98 30.36,56.11 30.54,56.11 30.66,55.98 30.66,55.34 30.98,55.02 31.49,55.02 31.76,55.29 31.76,55.41 31.88,55.54 36.41,55.54 36.64,55.31 36.64,55.13 36.62,55.12 36.62,54.94 36.75,54.82 36.93,54.82 36.94,54.83 37.12,54.83 37.25,54.7 37.25,54.52 37.24,54.51 37.24,54.33 37.36,54.21 37.54,54.21 37.55,54.22 37.73,54.22 37.86,54.09 37.86,53.91 37.85,53.9 37.85,53.72 37.97,53.59 38.15,53.59 38.16,53.61 38.34,53.61 38.47,53.48 38.47,53.3 38.46,53.29 38.46,53.11 38.58,52.98 38.76,52.98 38.77,53 38.95,53 39.08,52.87 39.08,52.69 39.07,52.68 39.07,52.5 39.19,52.37 39.37,52.37 39.38,52.38 39.56,52.38 39.69,52.26 39.69,52.08 39.68,52.07 39.68,51.89 39.8,51.76 39.98,51.76 40,51.77 40.17,51.77 40.34,51.61 40.34,51.43 40.32,51.42 40.32,51.24 40.45,51.12 40.63,51.12 40.64,51.13 40.82,51.13 41.27,50.67 41.27,50.44 41.15,50.32 41.02,50.19 41.02,50.01 41.15,49.89 41.27,49.76 41.27,49.4 40.89,49.02 40.89,48.79 40.77,48.67 40.77,48.36 40.89,48.23 40.89,47.12 41.63,46.38 41.63,45.28 41.81,45.1 41.81,44.93 42.04,44.7 42.04,43.1 41.64,42.7 v1(41.64,42.52)
DCLK_P: length 53.2
  TOP w0.152: U9.E3 v1(41.64,41.72)
  LY3-SIGNAL w0.127: v1(41.64,41.72) 41.64,41.77 42.08,42.21 42.08,42.67 42.33,42.93 42.59,42.93 42.81,43.15 42.81,43.47 42.8,43.48 42.8,43.96 42.81,43.97 42.81,44.27 42.8,44.28 42.8,44.41 42.14,45.07 42.14,45.24 41.96,45.42 41.96,46.52 41.22,47.25 41.22,48.89 41.61,49.27 41.61,50.81 36.55,55.87 31.75,55.87 31.43,55.55 31.43,55.42 31.35,55.35 31.12,55.35 30.99,55.47 30.99,56.12 30.67,56.44 30.22,56.44 29.9,56.12 29.9,55.42 29.78,55.3 29.6,55.3 29.47,55.42 29.47,56.12 29.15,56.44 28.7,56.44 28.38,56.12 28.38,55.42 28.25,55.3 28.07,55.3 27.95,55.42 27.95,56.12 27.63,56.44 27.17,56.44 26.85,56.12 26.85,55.42 26.73,55.3 26.55,55.3 26.42,55.42 26.42,56.12 26.1,56.44 25.65,56.44 25.33,56.12 25.33,55.42 25.2,55.3 25.02,55.3 24.9,55.42 24.9,56.12 24.58,56.44 24.13,56.44 23.81,56.12 23.81,55.99 23.68,55.87 10.76,55.87 v2(10.29,56.34)
DCLKIN_FPGA_N: length 53.2
  TOP w0.152: U9.F3 v1(41.64,40.92)
  LY5-SIGNAL w0.127: v2(5.21,39.83) 5.68,40.3 17.44,40.3 18.24,39.5 18.91,39.5 19.23,39.82 19.23,40.01 19.36,40.13 19.54,40.13 19.67,40.01 19.67,39.18 19.99,38.86 20.44,38.86 20.76,39.18 20.76,40.01 20.88,40.13 21.06,40.13 21.19,40.01 21.19,39.18 21.51,38.86 21.96,38.86 22.28,39.18 22.28,40.01 22.41,40.13 22.59,40.13 22.71,40.01 22.71,39.18 23.03,38.86 23.49,38.86 23.81,39.18 23.81,40.01 23.93,40.13 24.11,40.13 24.24,40.01 24.24,39.18 24.56,38.86 25.01,38.86 25.33,39.18 25.33,40.01 25.46,40.13 25.64,40.13 25.76,40.01 25.76,39.82 26.08,39.5 26.91,39.5 27.08,39.66 27.56,39.66 27.69,39.54 27.69,39.39 28.01,39.07 28.46,39.07 28.78,39.39 28.78,40.21 28.91,40.34 29.09,40.34 29.21,40.21 29.21,39.39 29.53,39.07 29.98,39.07 30.3,39.39 30.3,40.21 30.43,40.34 30.61,40.34 30.74,40.21 30.74,39.39 31.06,39.07 31.51,39.07 31.83,39.39 31.83,39.57 31.95,39.7 32.74,39.7 33.34,40.3 33.67,40.3 33.91,40.06 34.09,40.06 34.33,40.3 34.53,40.3 34.7,40.13 34.96,40.13 35.13,40.3 35.4,40.3 35.56,40.13 35.83,40.13 35.99,40.3 36.26,40.3 36.48,40.08 36.93,40.08 37.15,40.3 37.71,40.3 37.81,40.2 38.25,40.2 39.07,40.2 39.59,39.68 41.08,39.68 41.27,39.88 41.27,40.37 41.54,40.63 41.54,40.81 v1(41.64,40.92)
DCLKIN_FPGA_P: length 53.2
  TOP w0.152: U9.F4 v1(42.44,40.92)
  LY5-SIGNAL w0.127: v1(42.44,40.92) 42.01,41.35 41.53,41.35 41.21,41.03 41.21,41.07 40.99,41.28 40.69,41.28 40.48,41.07 40.48,40.88 40.29,40.88 40.08,40.67 40.08,40.53 39.21,40.53 37.95,40.53 37.85,40.63 33.2,40.63 32.6,40.03 31.82,40.03 31.5,39.71 31.5,39.52 31.37,39.4 31.19,39.4 31.07,39.52 31.07,40.35 30.75,40.67 30.29,40.67 29.97,40.35 29.97,39.52 29.85,39.4 29.67,39.4 29.54,39.52 29.54,40.35 29.22,40.67 28.77,40.67 28.45,40.35 28.45,39.52 28.32,39.4 28.14,39.4 28.02,39.52 28.02,39.67 27.7,39.99 26.94,39.99 26.77,39.83 26.22,39.83 26.09,39.95 26.09,40.14 25.77,40.46 25.32,40.46 25,40.14 25,39.32 24.87,39.19 24.69,39.19 24.57,39.32 24.57,40.14 24.25,40.46 23.8,40.46 23.48,40.14 23.48,39.32 23.35,39.19 23.17,39.19 23.04,39.32 23.04,40.14 22.72,40.46 22.27,40.46 21.95,40.14 21.95,39.32 21.83,39.19 21.65,39.19 21.52,39.32 21.52,40.14 21.2,40.46 20.75,40.46 20.43,40.14 20.43,39.32 20.3,39.19 20.12,39.19 20,39.32 20,40.14 19.68,40.46 19.22,40.46 18.9,40.14 18.9,39.95 18.78,39.83 18.37,39.83 17.57,40.63 5.68,40.63 v2(5.21,41.1)
DM: length 14.2
  TOP w0.14: J2.2 95.14,61.78 94.89,61.54 94.89,60.83 94.89,60.83 94.89,50.35 94.98,50.25 U4.7
DONE_0: length 72.5
  TOP w0.152: v1(48.01,28.19) R20.2 ; v1(105.03,26.67) 105.03,21.46 105.35,21.14 U20.3 ; U9.P10 v1(48.04,33.72)
  LY3-SIGNAL w0.127: v1(105.03,26.67) 92.88,26.67 92.5,27.05 92.08,27.05 91.57,26.54 61.48,26.54 61.37,26.65 61.06,26.65 60.95,26.54 60.21,26.54 60.1,26.65 59.79,26.65 59.68,26.54 59.06,26.54 58.95,26.65 58.65,26.65 58.54,26.54 53.34,26.54 52.58,27.3 48.39,27.3 R20.2 v1(48.01,28.19)
  LY5-SIGNAL w0.127: v1(48.04,33.72) 47.62,33.3 47.62,29.08 48.01,28.7 v1(48.01,28.19)
