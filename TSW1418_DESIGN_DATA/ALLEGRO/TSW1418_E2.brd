# Allegro board TSW1418_E2.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DP: length 14.2
  TOP w0.14: U4.8 94.48,50.25 94.58,50.35 94.58,60.96 94.58,60.96 94.58,61.54 94.34,61.78 J2.3
EEDATA: length 8.1
  TOP w0.152: U4.61 101.84,45.68 104.29,48.13 R10.1 U5.3
FCLK_N: length 53.2
  TOP w0.152: v1(42.44,42.52) 42.84,42.12 U9.D4
  LY3-SIGNAL w0.127: v2(11.56,57.61) 12.03,58.08 17.99,58.08 18.31,58.4 18.31,58.55 18.44,58.67 18.61,58.67 18.74,58.55 18.74,57.8 19.06,57.48 19.51,57.48 19.83,57.8 19.83,58.55 19.96,58.67 20.14,58.67 20.27,58.55 20.27,57.8 20.59,57.48 21.04,57.48 21.36,57.8 21.36,58.55 21.48,58.67 21.66,58.67 21.79,58.55 21.79,57.83 22.11,57.51 22.56,57.51 22.88,57.83 22.88,57.95 23.01,58.08 39.5,58.08 41.92,55.65 41.92,55.36 42.08,55.2 42.38,55.2 42.78,54.8 42.78,53.84 42.55,53.61 42.55,53.41 42.78,53.17 42.78,52.98 42.55,52.74 42.55,52.54 42.78,52.31 42.78,51.76 42.55,51.53 42.55,51.33 42.78,51.1 42.78,46.65 43.1,46.34 43.1,46.16 42.91,45.97 42.91,45.95 42.7,45.74 42.7,45.31 43.68,44.33 43.68,43.97 43.68,43.17 43.39,42.88 43.01,42.88 42.65,42.52 v1(42.44,42.52)
FCLK_P: length 53.2
  TOP w0.152: v1(43.24,42.52) 43.64,42.12 U9.D5
  LY3-SIGNAL w0.127: v2(11.56,58.88) 12.03,58.41 17.85,58.41 17.98,58.53 17.98,58.68 18.3,59 18.75,59 19.07,58.68 19.07,57.94 19.2,57.81 19.38,57.81 19.5,57.94 19.5,58.68 19.82,59 20.28,59 20.6,58.68 20.6,57.94 20.72,57.81 20.9,57.81 21.03,57.94 21.03,58.68 21.35,59 21.8,59 22.12,58.68 22.12,57.96 22.25,57.84 22.43,57.84 22.55,57.96 22.55,58.09 22.87,58.41 39.64,58.41 43.11,54.94 43.11,46.79 43.43,46.47 43.43,46.02 43.24,45.83 43.24,45.81 43.03,45.61 43.03,45.45 43.99,44.48 44.19,44.48 44.41,44.27 44.41,44.07 44.41,44.07 44.41,43.17 44.2,42.95 43.93,42.95 43.49,42.52 v1(43.24,42.52)
FIFO_CLKOUT: length 8.5
  TOP w0.152: U4.32 88.54,39.75 84.71,39.75 83.3,41.16 U3.10
FIFO_D0: length 12.6
  TOP w0.152: U3.24 82.2,46.76 85.98,50.55 90.17,50.55 90.48,50.23 U4.16
FIFO_D1: length 8.2
  TOP w0.152: U4.17 83.38,47.18 82.56,46.36 U3.23
FIFO_D2: length 8.1
  TOP w0.152: U4.18 83.64,46.68 82.92,45.96 U3.22
FIFO_D3: length 8.1
  TOP w0.152: U3.21 83.16,45.56 83.78,46.18 arc(83.82,46.22) 83.88,46.23 84.28,46.23 84.33,46.18 U4.19
FIFO_D4: length 7.8
  TOP w0.152: U4.21 86.25,45.18 86.23,45.16 U3.20
FIFO_D5: length 7.9
  TOP w0.152: U3.19 86.23,44.76 86.31,44.68 U4.22
FIFO_D6: length 7.9
  TOP w0.152: U3.18 86.23,44.36 86.41,44.18 U4.23
FIFO_D7: length 7.9
  TOP w0.152: U4.24 88.61,43.69 85.47,43.69 85.35,43.56 U3.16
FIFO_OEN: length 10.9
  TOP w0.152: U3.9 80.77,40.77 83.19,40.77 84.84,39.12 88.77,39.12 90.08,37.81 U4.33
FIFO_RDN: length 8
  TOP w0.152: U4.28 87.09,41.68 86.77,42.01 84.15,42.01 84.11,41.96 U3.12
FIFO_RXFN: length 7.9
  TOP w0.152: U4.26 88.6,42.67 85.47,42.67 85.38,42.76 U3.14
FIFO_TXEN: length 7.9
  TOP w0.152: U3.13 87.05,42.36 87.23,42.18 U4.27
FIFO_WRN: length 8.1
  TOP w0.152: U4.29 87.09,41.18 86.61,41.66 84.2,41.66 84.11,41.56 U3.11
FMC_GPIO_0: length 51.6
  TOP w0.152: v1(54.44,36.12) U9.L18
  LY5-SIGNAL w0.127: v2(9.02,34.75) 9.07,34.75 9.65,34.16 16.54,34.16 20.32,30.39 39.15,30.39 40.51,31.75 41.27,31.75 42.04,32.51 42.67,32.51 43.31,33.15 43.56,33.15 43.68,33.26 43.68,34.28 44.35,34.95 46.75,34.95 47.37,35.57 47.37,35.96 47.89,36.48 52.11,36.48 52.33,36.7 54.1,36.7 54.44,36.36 v1(54.44,36.12)
FMC_GPIO_1: length 51.8
  TOP w0.152: v1(54.44,35.32) U9.M18
  LY5-SIGNAL w0.127: v1(54.44,35.32) 54.08,35.69 47.88,35.69 46.99,34.8 46.99,34.29 46.78,34.08 44.69,34.08 44.45,33.84 44.45,32.26 43.93,31.73 42.15,31.73 40.26,29.84 19.3,29.84 17.53,31.62 10.03,31.62 9.78,31.88 9.78,32.72 v2(9.02,33.48)
FMC_GPIO_2: length 46.5
  TOP w0.152: U9.R12 49.24,33.24 48.82,32.82 48.82,30.41 48.01,29.59 47.75,29.59 47.12,28.96 43.56,28.96 v1(42.29,27.69)
  LY5-SIGNAL w0.127: v2(9.02,30.94) 9.65,30.3 9.65,29.46 10.03,29.08 10.67,29.08 10.79,28.96 10.79,27.81 10.92,27.69 v1(42.29,27.69)
FMC_GPIO_3: length 51.6
  TOP w0.152: U9.R13 v1(50.44,32.92)
  LY5-SIGNAL w0.127: v2(9.02,29.67) 9.02,29.21 9.65,28.57 9.65,27.17 10.26,26.56 17.24,26.56 17.53,26.28 41.92,26.28 42.44,26.8 50.42,26.8 50.93,27.3 50.93,28.46 50.7,28.69 50.69,28.69 50.04,29.34 50.04,32.38 50.44,32.79 v1(50.44,32.92)
FMC_MISO: length 57.3
  TOP w0.152: v1(51.82,22.61) 52.91,23.7 52.91,30.53 52.83,30.61 52.83,31.98 52.68,32.13 52.29,32.13 52.06,32.36 52.06,34.28 51.82,34.52 51.24,34.52 U9.N14
  LY5-SIGNAL w0.127: v2(9.02,23.32) 9.07,23.32 9.78,22.61 v1(51.82,22.61)
FMC_MOSI: length 56.5
  TOP w0.152: v1(50.93,21.34) 52.45,21.34 54.1,22.99 54.1,28.83 53.59,29.34 53.59,30.73 53.63,30.76 53.63,31.04 53.92,31.34 54.2,31.34 54.42,31.56 54.42,32.14 U9.T18
  LY5-SIGNAL w0.127: v1(50.93,21.34) 20.19,21.34 20.07,21.46 9.65,21.46 9.07,22.05 v2(9.02,22.05)
FMC_MOSI_EN: length 58.9
  TOP w0.152: v1(50.8,18.67) 54.85,22.72 54.85,32.65 54.18,33.32 U9.R18
  LY5-SIGNAL w0.127: v1(50.8,18.67) 20.83,18.67 20.57,18.92 9.65,18.92 9.07,19.51 v2(9.02,19.51)
FMC_SCL: length 61.2
  TOP w0.152: U9.P14 v1(51.24,33.72)
  LY5-SIGNAL w0.127: v2(9.02,18.24) 9.07,18.24 9.65,17.65 20.83,17.65 21.08,17.4 50.93,17.4 52.31,18.78 52.31,26.42 53.09,27.19 53.09,31.24 52.45,31.88 52.45,33.15 51.88,33.72 v1(51.24,33.72)
FMC_SCLK: length 56.7
  TOP w0.152: U9.L13 v1(50.44,36.12)
  LY5-SIGNAL w0.127: v2(9.02,27.13) 9.86,26.29 10.14,26.29 10.15,26.28 10.79,26.28 10.92,26.15 10.92,25.65 11.56,25.02 v1(49.78,25.02)
  BOTTOM w0.152: v1(50.44,36.12) 50.44,35.91 51.33,35.03 51.33,35.03 51.82,34.54 51.82,32.51 53.21,31.11 53.21,29.08 51.31,27.18 50.42,27.18 49.78,26.54 v1(49.78,25.02)
FMC_SDA_IN: length 64.6
  TOP w0.152: U9.P18 v1(54.44,33.72)
  LY5-SIGNAL w0.127: v1(54.44,33.72) 54.44,30.17 54.67,29.95 54.67,21.9 53.98,21.21 53.98,16.51 51.89,14.43 21.08,14.43 20.37,13.72 9.65,13.72 9.02,14.35 v2(9.02,14.43)
FMC_SDA_OUT: length 63.6
  TOP w0.152: U9.N17 v1(53.64,34.52)
  LY5-SIGNAL w0.127: v2(9.02,15.7) 9.02,15.62 9.53,15.11 20.88,15.11 21.46,15.7 51.51,15.7 53.59,17.78 53.59,31.37 53.21,31.75 53.21,34.08 v1(53.64,34.52)
FMC_SEN: length 56.4
  TOP w0.152: U9.M13 v1(50.44,35.32)
  LY5-SIGNAL w0.127: v1(50.44,35.32) 50.44,35.28 50.88,34.85 50.88,33.57 51.16,33.28 51.55,33.28 51.82,33.02 51.82,31.61 51.56,31.35 51.56,30.1 52.32,29.34 52.32,27.69 50.93,26.29 50.93,25.15 49.66,23.88 10.03,23.88 9.53,24.38 9.53,25.35 v2(9.02,25.86)
FPGA-TP0: length 26.7
  TOP w0.152: U9.M2 41.24,35.66 40.89,35.31 39.62,35.31 39.12,34.8 39.12,13.72 R33.1
FPGA-TP1: length 33.1
  TOP w0.254: U9.M3 v1(41.64,35.32)
  LY3-SIGNAL w0.127: v1(41.64,35.32) 41.64,35.29 41.27,34.92 41.27,32.64 41.53,32.38 42.19,32.38 42.29,32.48 43.84,32.48 43.94,32.38 43.94,14.73 41.27,12.06 v1(41.27,6.6)
FPGA_CLK_N: length 67.7
  TOP w0.152: U9.P5 v1(43.24,33.72)
  LY5-SIGNAL w0.127: v1(43.24,33.72) 42.93,34.04 42.64,34.04 42.6,34.08 42.29,34.08 42.25,34.04 42.14,34.04 41.83,33.72 40.48,33.72 40.25,33.95 20.15,33.95 18.83,35.27 4.55,35.27 4.19,35.63 4.19,56.39 4.7,56.9 8,56.9 8.38,56.52 8.38,55.7 v2(7.75,55.07)
FPGA_CLK_P: length 67.7
  TOP w0.152: U9.N5 43.64,34.92 v1(43.24,34.52)
  LY5-SIGNAL w0.127: v2(7.75,56.34) 7.16,55.75 4.95,55.75 4.52,55.32 4.52,35.76 4.69,35.6 18.97,35.6 20.29,34.28 20.92,34.28 21.04,34.41 21.04,34.42 21.17,34.54 21.35,34.54 21.48,34.42 21.48,34.41 21.6,34.28 21.78,34.28 21.91,34.41 21.91,34.42 22.03,34.54 22.21,34.54 22.34,34.42 22.34,34.41 22.47,34.28 22.65,34.28 22.77,34.41 22.77,34.42 22.9,34.54 23.08,34.54 23.2,34.42 23.2,34.41 23.33,34.28 23.51,34.28 23.64,34.41 23.64,34.42 23.76,34.54 23.94,34.54 24.07,34.42 24.07,34.41 24.19,34.28 24.37,34.28 24.5,34.41 24.5,34.42 24.63,34.54 24.8,34.54 24.93,34.42 24.93,34.41 25.06,34.28 25.24,34.28 25.36,34.41 25.36,34.42 25.49,34.54 25.67,34.54 25.79,34.42 25.79,34.41 25.92,34.28 26.1,34.28 26.23,34.41 26.23,34.42 26.35,34.54 26.53,34.54 26.66,34.42 26.66,34.41 26.78,34.28 26.96,34.28 27.09,34.41 27.09,34.42 27.22,34.54 27.39,34.54 27.52,34.42 27.52,34.41 27.65,34.28 27.83,34.28 27.95,34.41 27.95,34.42 28.08,34.54 28.26,34.54 28.38,34.42 28.38,34.41 28.51,34.28 28.69,34.28 28.82,34.41 28.82,34.42 28.94,34.54 29.12,34.54 29.25,34.42 29.25,34.41 29.37,34.28 29.55,34.28 29.68,34.41 29.68,34.42 29.81,34.54 29.99,34.54 30.11,34.42 30.11,34.41 30.24,34.28 30.42,34.28 30.54,34.41 30.54,34.42 30.67,34.54 30.85,34.54 30.98,34.42 30.98,34.41 31.1,34.28 31.28,34.28 31.41,34.41 31.41,34.42 31.53,34.54 31.71,34.54 31.84,34.42 31.84,34.41 31.97,34.28 32.14,34.28 32.27,34.41 32.27,34.42 32.4,34.54 32.58,34.54 32.7,34.42 32.7,34.41 32.83,34.28 33.01,34.28 33.13,34.41 33.13,34.42 33.26,34.54 33.44,34.54 33.57,34.42 33.57,34.41 33.69,34.28 33.87,34.28 34,34.41 34,34.42 34.12,34.54 34.3,34.54 34.43,34.42 34.43,34.41 34.56,34.28 34.74,34.28 34.86,34.41 34.86,34.42 34.99,34.54 35.17,34.54 35.29,34.42 35.29,34.41 35.42,34.28 35.6,34.28 35.81,34.49 36.07,34.49 36.28,34.28 36.85,34.28 37.03,34.47 37.41,34.47 37.6,34.28 38.21,34.28 38.35,34.42 38.65,34.42 38.78,34.28 40.38,34.28 40.62,34.05 41.69,34.05 42.01,34.37 42.11,34.37 42.16,34.41 42.73,34.41 42.78,34.37 43.06,34.37 43.08,34.35 v1(43.24,34.52)
FPGA_REFCLK_N: length 66.9
  TOP w0.127: U9.T4 42.84,32.52 v1(42.44,32.12)
  LY3-SIGNAL w0.127: v1(42.44,32.12) 42.68,31.88 42.68,31.76 42.42,31.5 41.62,31.5 41.42,31.7 41.19,31.7 40.99,31.5 40.76,31.5 40.56,31.7 40.33,31.7 40.12,31.5 39.9,31.5 39.69,31.7 39.46,31.7 39.26,31.5 39.03,31.5 38.83,31.7 38.6,31.7 38.4,31.5 38.17,31.5 37.97,31.7 37.74,31.7 37.53,31.5 37.31,31.5 37.1,31.7 36.87,31.7 36.67,31.5 36.44,31.5 36.24,31.7 36.01,31.7 35.81,31.5 35.58,31.5 35.37,31.7 35.15,31.7 34.94,31.5 34.71,31.5 34.51,31.7 34.28,31.7 34.08,31.5 32.63,31.5 32.48,31.65 32.2,31.65 32.05,31.5 25.27,31.5 25.02,31.75 4.57,31.75 4.32,32 4.32,52.45 4.86,53 8.55,53 v2(9.02,52.53)
FPGA_REFCLK_P: length 66.9
  TOP w0.127: v1(43.24,32.12) 43.64,32.52 U9.T5
  LY3-SIGNAL w0.127: v2(9.02,53.8) 8.55,53.33 4.73,53.33 3.99,52.59 3.99,31.87 4.44,31.42 24.88,31.42 25.14,31.17 42.56,31.17 43.01,31.62 43.01,31.88 v1(43.24,32.12)
FTDI-BB-RDSTBN: length 26.1
  TOP w0.127: 55.21,38.52 53.64,38.52
  TOP w0.152: U3.46 70.62,38.36 70.23,37.97 70.23,36.2 69.85,35.81 65.02,35.81 62.32,38.52 55.21,38.52 ; 53.64,38.52 U9.J17
FTDI-BB-WRSTBN: length 28.3
  TOP w0.152: U3.45 77.06,38.76 77.52,38.3 77.52,36.83 76.2,35.51 64.69,35.51 62.08,38.12 U9.J18
FTDI-FIFO-CLKOUT: length 25.6
  TOP w0.127: 55.59,41.69 52.04,41.69 51.64,42.08 U9.D15
  TOP w0.152: 55.59,41.69 63.02,41.69 64.31,42.98 72.72,42.98 74.13,41.56 U3.38
FTDI-FIFO-D0: length 28.5
  TOP w0.152: U9.A13 50.04,46.11 51.57,47.64 56.12,47.64 57,46.76 U3.25
FTDI-FIFO-D1: length 28.8
  TOP w0.127: 50.92,46.3 50.92,45.56 50.44,45.08 50.44,44.12
  TOP w0.152: 50.44,44.12 U9.B13 ; U3.26 56.89,46.36 55.92,47.33 51.96,47.33 50.92,46.3
FTDI-FIFO-D2: length 27.3
  TOP w0.152: U3.27 56.78,45.96 55.71,47.03 52.36,47.03 52.2,47.03 51.22,46.04 51.22,45.44 50.84,45.07 U9.A14
FTDI-FIFO-D3: length 27.5
  TOP w0.127: 51.24,44.12 51.24,44.63 51.28,44.66 51.28,44.67 51.49,44.89 51.5,44.89 52.18,45.57 52.18,46.24 52.67,46.74 52.91,46.74 55.22,46.74 56.39,45.56
  TOP w0.152: U3.28 56.39,45.56 ; 51.24,44.12 U9.B14
FTDI-FIFO-D4: length 26
  TOP w0.152: U3.29 56.06,45.16 54.78,46.44 52.92,46.44 52.47,45.99 52.47,45.45 52.09,45.06 52.09,44.96 U9.A15
FTDI-FIFO-D5: length 29.3
  TOP w0.152: U3.30 v1(77.16,44.76) ; U9.C14 50.84,42.92 v1(51.24,43.32)
  LY3-SIGNAL w0.127: v1(77.16,44.76) 55.06,44.76 54.36,45.47 52.7,45.47 51.68,44.44 51.68,43.75 v1(51.24,43.32)
FTDI-FIFO-D6: length 24.7
  TOP w0.152: U3.31 74.51,44.36 74.04,44.83 55.37,44.83 54.74,45.47 52.83,45.47 52.78,45.41 52.78,45.32 52.44,44.99 U9.A16
FTDI-FIFO-D7: length 27.5
  TOP w0.152: U3.33 v1(77.72,43.56) ; U9.B16 v1(52.84,44.12)
  LY3-SIGNAL w0.127: v1(52.84,44.12) 52.91,44.12 53.27,43.75 76.89,43.75 77.08,43.56 v1(77.72,43.56)
FTDI-FIFO-OEN: length 26.2
  TOP w0.152: U3.39 v1(77.33,41.16) ; U9.D17 v1(53.64,42.52)
  LY3-SIGNAL w0.127: v1(77.33,41.16) 73.64,41.16 72.77,42.04 54.61,42.04 54.13,42.52 v1(53.64,42.52)
FTDI-FIFO-RDN: length 22.5
  TOP w0.152: U9.B18 73.12,43.72 74.48,42.36 U3.36
FTDI-FIFO-RXFN: length 22.5
  TOP w0.127: U9.A18 54.92,44.52
  TOP w0.152: U3.34 74.95,43.16 73.59,44.52 54.92,44.52
FTDI-FIFO-TXEN: length 23.4
  TOP w0.127: 53.64,44.12 55.19,44.12
  TOP w0.152: U9.B17 53.64,44.12 ; 55.19,44.12 73.36,44.12 74.68,42.8 75.91,42.8 U3.35
FTDI-FIFO-WRN: length 23.4
  TOP w0.152: U9.C17 53.64,43.32 54.42,43.32 54.43,43.31 72.9,43.31 74.17,42.04 75.88,42.04 U3.37
HA02_N: length 53.2
  TOP w0.152: v1(44.84,43.32) 45.24,42.92 U9.C7
  LY5-SIGNAL w0.127: v1(44.84,43.32) 45.04,43.32 45.62,43.89 45.62,46.25 44.88,46.99 44.88,49.01 42.73,51.17 37.69,51.17 37.39,51.46 37.04,51.46 36.74,51.17 35.49,51.17 35.2,50.87 34.74,50.87 34.42,51.19 34.42,51.33 34.3,51.46 34.12,51.46 33.99,51.33 33.99,51.19 33.67,50.87 33.22,50.87 32.9,51.19 32.9,51.33 32.77,51.46 32.59,51.46 32.47,51.33 32.47,51.19 32.15,50.87 31.7,50.87 31.38,51.19 31.38,51.33 31.25,51.46 31.07,51.46 30.94,51.33 30.94,51.19 30.62,50.87 30.17,50.87 29.85,51.19 29.85,51.33 29.73,51.46 29.55,51.46 29.42,51.33 29.42,51.19 29.1,50.87 28.65,50.87 28.33,51.19 28.33,51.33 28.2,51.46 28.02,51.46 27.9,51.33 27.9,51.19 27.58,50.87 27.12,50.87 26.8,51.19 26.8,51.33 26.68,51.46 26.35,51.46 26.05,51.17 24.6,51.17 24.42,50.98 24.17,50.98 23.99,51.17 23.74,51.17 23.55,50.98 23.31,50.98 23.12,51.17 21.86,51.17 21.62,50.93 21.43,50.93 21.19,51.17 21,51.17 20.76,50.93 20.57,50.93 20.33,51.17 20.13,51.17 19.9,50.93 19.7,50.93 19.46,51.17 19.27,51.17 19.03,50.93 18.84,50.93 18.6,51.17 17.84,51.17 17.27,51.73 5.68,51.73 v2(5.21,51.26)
HA02_P: length 53.2
  TOP w0.152: U9.D8 46.04,42.12 v1(45.64,42.52)
  LY5-SIGNAL w0.127: v1(45.64,42.52) 45.64,42.8 46.05,43.21 46.05,44.01 45.95,44.12 45.95,46.39 45.21,47.13 45.21,49.15 42.87,51.5 37.82,51.5 37.53,51.79 36.9,51.79 36.6,51.5 35.35,51.5 35.06,51.2 34.88,51.2 34.75,51.33 34.75,51.47 34.43,51.79 33.98,51.79 33.66,51.47 33.66,51.33 33.54,51.2 33.36,51.2 33.23,51.33 33.23,51.47 32.91,51.79 32.46,51.79 32.14,51.47 32.14,51.33 32.01,51.2 31.83,51.2 31.71,51.33 31.71,51.47 31.39,51.79 30.93,51.79 30.61,51.47 30.61,51.33 30.49,51.2 30.31,51.2 30.18,51.33 30.18,51.47 29.86,51.79 29.41,51.79 29.09,51.47 29.09,51.33 28.96,51.2 28.78,51.2 28.66,51.33 28.66,51.47 28.34,51.79 27.89,51.79 27.57,51.47 27.57,51.33 27.44,51.2 27.26,51.2 27.13,51.33 27.13,51.47 26.81,51.79 26.21,51.79 25.92,51.5 17.97,51.5 17.41,52.06 5.68,52.06 v2(5.21,52.53)
HA03_N: length 53.2
  TOP w0.152: v1(44.84,42.52) 45.24,42.12 U9.D7
  LY5-SIGNAL w0.127: v1(44.84,42.52) 44.86,42.52 45.22,42.15 45.97,42.15 46.21,41.92 46.68,41.92 46.81,42.05 46.81,43.79 46.28,44.32 46.28,47.59 45.64,48.22 45.64,50.34 44.42,51.56 43.94,51.56 42.51,53 25.53,53 25.29,52.76 25.1,52.76 24.86,53 24.67,53 24.43,52.76 24.24,52.76 24,53 23.35,53 23.22,52.87 23.22,52.73 23.1,52.6 22.92,52.6 22.79,52.73 22.79,52.87 22.66,53 22.49,53 22.36,52.87 22.36,52.86 22.23,52.73 22.05,52.73 21.93,52.86 21.93,52.87 21.8,53 6.95,53 v2(6.48,52.53)
HA03_P: length 53.2
  TOP w0.152: v1(44.84,41.72) 45.24,41.32 U9.E7
  LY5-SIGNAL w0.127: v1(44.84,41.72) 45.24,41.33 45.95,41.33 46.21,41.59 46.82,41.59 47.14,41.91 47.14,43.93 46.61,44.46 46.61,47.73 45.97,48.36 45.97,50.48 44.56,51.89 44.08,51.89 42.64,53.33 6.95,53.33 v2(6.48,53.8)
HA04_N: length 53.2
  TOP w0.14: U9.B1 40.2,43.97 39.93,43.97 39.45,44.45 39.45,44.7 38.68,45.47 38.68,46.11 v1(38.44,46.23)
  LY3-SIGNAL w0.127: v2(10.29,51.26) 10.76,51.73 17.49,51.73 17.78,51.44 17.97,51.44 18.1,51.31 18.1,51.12 18.74,50.47 19.2,50.47 20.53,51.8 20.71,51.8 20.83,51.67 20.83,51.49 17.86,48.52 17.86,48.07 18.18,47.75 18.63,47.75 21.6,50.72 21.78,50.72 21.91,50.6 21.91,50.42 18.93,47.44 18.93,46.99 19.25,46.67 19.71,46.67 21.04,48 21.22,48 22.48,46.74 23.61,46.74 23.96,47.09 24.23,47.09 24.36,46.97 24.36,46.78 24.68,46.46 25.21,46.46 25.49,46.74 38.78,46.74 38.93,46.59 38.93,46.46 v1(38.44,46.23)
HA04_P: length 53.2
  TOP w0.14: v1(39.23,46.23) 38.99,45.98 38.99,45.59 39.75,44.83 39.75,44.58 40.06,44.27 40.2,44.27 U9.A1
  LY3-SIGNAL w0.127: v2(10.29,52.53) 10.76,52.06 17.62,52.06 17.94,51.74 18.12,51.74 18.15,51.77 18.33,51.77 18.46,51.65 18.46,51.47 18.43,51.44 18.43,51.26 18.88,50.8 19.06,50.8 20.39,52.13 20.84,52.13 21.16,51.81 21.16,51.36 18.19,48.38 18.19,48.2 18.31,48.08 18.49,48.08 21.47,51.05 21.92,51.05 22.24,50.73 22.24,50.28 19.27,47.31 19.27,47.13 19.39,47 19.57,47 20.9,48.33 21.35,48.33 22.62,47.07 23.47,47.07 23.83,47.42 24.37,47.42 24.69,47.1 24.69,46.91 24.82,46.79 25.07,46.79 25.35,47.07 26.46,47.07 26.62,47.22 26.9,47.22 27.05,47.07 38.91,47.07 39.26,46.72 39.26,46.46 v1(39.23,46.23)
HA05_N: length 62.4
  TOP w0.14: U9.A3 42.29,44.77 42.29,45.21 41.66,45.85 41.66,46.74 40.77,47.62 30.34,47.62 30.03,47.93 30.03,48.84 29.9,48.97 29.71,48.97 29.58,48.84 29.58,46.51 29.27,46.2 28.84,46.2 28.53,46.51 28.53,48.92 28.4,49.05 28.21,49.05 28.08,48.92 28.08,46.51 27.78,46.2 27.34,46.2 27.03,46.51 27.03,48.92 26.9,49.05 26.72,49.05 26.59,48.92 26.59,46.51 26.28,46.2 25.84,46.2 25.53,46.51 25.53,48.92 25.4,49.05 25.22,49.05 25.09,48.92 25.09,46.51 24.78,46.2 24.34,46.2 24.03,46.51 24.03,48.92 23.9,49.05 23.72,49.05 23.59,48.92 23.59,47.93 23.28,47.62 22.05,47.62 21.64,48.03 21.64,53.25 21.2,53.7 19.99,53.7 19.84,53.54 19.54,53.54 19.39,53.7 19.1,53.7 18.95,53.54 18.65,53.54 18.5,53.7 18.21,53.7 18.06,53.54 17.77,53.54 17.61,53.7 17.25,53.7 16.76,53.21 12.32,53.21 11.63,52.53 11.56,52.53
HA05_P: length 62.4
  TOP w0.14: U9.A4 42.6,44.77 42.6,45.34 41.96,45.97 41.96,46.86 40.89,47.93 30.46,47.93 30.33,48.06 30.33,48.97 30.02,49.28 29.59,49.28 29.28,48.97 29.28,46.64 29.15,46.51 28.96,46.51 28.83,46.64 28.83,49.04 28.53,49.35 28.09,49.35 27.78,49.04 27.78,46.64 27.65,46.51 27.47,46.51 27.34,46.64 27.34,49.04 27.03,49.35 26.59,49.35 26.28,49.04 26.28,46.64 26.15,46.51 25.97,46.51 25.84,46.64 25.84,49.04 25.53,49.35 25.09,49.35 24.78,49.04 24.78,46.64 24.65,46.51 24.47,46.51 24.34,46.64 24.34,49.04 24.03,49.35 23.59,49.35 23.28,49.04 23.28,48.06 23.15,47.93 22.17,47.93 21.95,48.16 21.95,53.38 21.32,54 17.25,54 16.89,54.36 12.19,54.36 11.63,53.8 11.56,53.8
HA06_N: length 53.2
  TOP w0.152: U9.B6 v1(44.04,44.12)
  LY5-SIGNAL w0.127: v2(5.21,47.45) 5.68,47.92 17.78,47.92 18.12,48.26 18.63,48.26 18.75,48.13 18.75,48.11 18.88,47.98 19.06,47.98 19.19,48.11 19.19,48.13 19.31,48.26 19.49,48.26 19.62,48.13 19.62,48.11 19.74,47.98 19.92,47.98 20.05,48.11 20.05,48.13 20.18,48.26 21.43,48.26 21.81,48.64 22.05,48.64 22.18,48.51 22.18,48.2 22.5,47.88 22.95,47.88 23.27,48.2 23.27,48.51 23.4,48.64 23.58,48.64 23.71,48.51 23.71,48.2 24.02,47.88 24.48,47.88 24.8,48.2 24.8,48.51 24.92,48.64 25.1,48.64 25.23,48.51 25.23,48.2 25.55,47.88 26,47.88 26.32,48.2 26.32,48.51 26.45,48.64 26.63,48.64 26.75,48.51 26.75,48.2 27.07,47.88 27.53,47.88 27.85,48.2 27.85,48.51 27.97,48.64 28.15,48.64 28.28,48.51 28.28,48.2 28.6,47.88 29.05,47.88 29.37,48.2 29.37,48.51 29.5,48.64 29.67,48.64 29.8,48.51 29.8,48.2 30.12,47.88 30.57,47.88 30.89,48.2 30.89,48.51 31.02,48.64 31.2,48.64 31.33,48.51 31.33,48.2 31.64,47.88 32.1,47.88 32.42,48.2 32.42,48.51 32.54,48.64 32.72,48.64 32.85,48.51 32.85,48.2 33.17,47.88 33.62,47.88 33.94,48.2 33.94,48.51 34.07,48.64 34.25,48.64 34.37,48.51 34.37,48.2 34.69,47.88 35.15,47.88 35.47,48.2 35.47,48.51 35.59,48.64 35.77,48.64 36.15,48.26 37.3,48.26 37.5,48.46 38.03,48.46 38.23,48.26 42.55,48.26 42.95,47.86 42.95,46.08 44.28,44.75 44.28,44.35 v1(44.04,44.12)
HA06_P: length 53.2
  TOP w0.152: U9.B7 v1(44.84,44.12)
  LY5-SIGNAL w0.127: v2(5.21,48.72) 5.68,48.25 17.64,48.25 17.98,48.59 21.29,48.59 21.67,48.97 22.19,48.97 22.51,48.65 22.51,48.34 22.64,48.21 22.82,48.21 22.94,48.34 22.94,48.65 23.26,48.97 23.72,48.97 24.04,48.65 24.04,48.34 24.16,48.21 24.34,48.21 24.47,48.34 24.47,48.65 24.79,48.97 25.24,48.97 25.56,48.65 25.56,48.34 25.69,48.21 25.86,48.21 25.99,48.34 25.99,48.65 26.31,48.97 26.76,48.97 27.08,48.65 27.08,48.34 27.21,48.21 27.39,48.21 27.52,48.34 27.52,48.65 27.83,48.97 28.29,48.97 28.61,48.65 28.61,48.34 28.73,48.21 28.91,48.21 29.04,48.34 29.04,48.65 29.36,48.97 29.81,48.97 30.13,48.65 30.13,48.34 30.26,48.21 30.44,48.21 30.56,48.34 30.56,48.65 30.88,48.97 31.34,48.97 31.66,48.65 31.66,48.34 31.78,48.21 31.96,48.21 32.09,48.34 32.09,48.65 32.41,48.97 32.86,48.97 33.18,48.65 33.18,48.34 33.31,48.21 33.48,48.21 33.61,48.34 33.61,48.65 33.93,48.97 34.38,48.97 34.7,48.65 34.7,48.34 34.83,48.21 35.01,48.21 35.14,48.34 35.14,48.65 35.45,48.97 35.91,48.97 36.29,48.59 37.16,48.59 37.36,48.79 38.16,48.79 38.37,48.59 42.68,48.59 43.28,47.99 43.28,46.22 44.61,44.89 44.61,44.35 v1(44.84,44.12)
HA07_N: length 53.2
  TOP w0.14: U9.E1 40.18,41.32 v1(39.88,41.02)
  LY3-SIGNAL w0.127: v2(6.48,48.72) 6.48,49.07 6.22,49.07 5.97,48.82 5.97,43.34 5.96,43.33 5.96,40.87 6.14,40.68 17.57,40.68 18.02,40.23 18.24,40.23 18.47,40.46 18.47,40.5 18.79,40.82 19.24,40.82 19.56,40.5 19.56,39.98 19.69,39.85 19.87,39.85 20,39.98 20,40.5 20.32,40.82 20.77,40.82 21.09,40.5 21.09,39.98 21.21,39.85 21.39,39.85 21.52,39.98 21.52,40.5 21.84,40.82 22.29,40.82 22.61,40.5 22.61,39.98 22.74,39.85 22.92,39.85 23.04,39.98 23.04,40.37 23.36,40.69 23.82,40.69 24.14,40.37 24.14,39.98 24.26,39.85 24.44,39.85 24.57,39.98 24.57,40.45 24.89,40.77 25.34,40.77 25.66,40.45 25.66,39.98 25.79,39.85 25.97,39.85 26.09,39.98 26.09,40.5 26.41,40.82 26.86,40.82 27.18,40.5 27.18,39.98 27.31,39.85 27.49,39.85 27.62,39.98 27.62,40.02 27.94,40.34 28.16,40.34 28.34,40.51 28.6,40.51 28.77,40.34 29.79,40.34 29.97,40.51 30.22,40.51 30.4,40.34 30.65,40.34 30.83,40.51 31.08,40.51 31.26,40.34 31.52,40.34 31.69,40.51 31.95,40.51 32.13,40.34 32.48,40.34 32.61,40.46 32.91,40.46 33.04,40.34 33.34,40.34 33.47,40.46 33.78,40.46 33.9,40.34 34.21,40.34 34.33,40.46 34.64,40.46 34.77,40.34 35.51,40.34 35.71,40.54 35.89,40.54 36.09,40.34 36.37,40.34 36.58,40.54 36.76,40.54 36.96,40.34 38.28,40.34 38.73,40.78 39.64,40.78 v1(39.88,41.02)
HA07_P: length 53.2
  LY3-SIGNAL w0.127: v2(6.48,49.99) 6.48,49.4 6.09,49.4 5.64,48.96 5.64,43.48 5.63,43.46 5.63,40.73 6.01,40.35 17.44,40.35 17.88,39.9 18.38,39.9 18.8,40.32 18.8,40.36 18.93,40.49 19.11,40.49 19.23,40.36 19.23,39.84 19.55,39.52 20.01,39.52 20.33,39.84 20.33,40.36 20.45,40.49 20.63,40.49 20.76,40.36 20.76,39.84 21.08,39.52 21.53,39.52 21.85,39.84 21.85,40.36 21.98,40.49 22.16,40.49 22.28,40.36 22.28,39.84 22.6,39.52 23.05,39.52 23.37,39.84 23.37,40.23 23.5,40.36 23.68,40.36 23.81,40.23 23.81,39.84 24.13,39.52 24.58,39.52 24.9,39.84 24.9,40.31 25.02,40.44 25.2,40.44 25.33,40.31 25.33,39.84 25.65,39.52 26.1,39.52 26.42,39.84 26.42,40.36 26.55,40.49 26.73,40.49 26.85,40.36 26.85,39.84 27.17,39.52 27.63,39.52 27.95,39.84 27.95,39.88 28.07,40.01 29.93,40.01 30.11,40.19 30.29,40.19 30.47,40.01 38.41,40.01 38.86,40.45 39.78,40.45 39.84,40.52 v1(40.44,40.52)
HA08_N: length 53.2
  TOP w0.152: v1(44.04,41.72) 44.44,41.32 U9.E6
  LY7-PWR w0.127: v1(44.04,41.72) 44.01,41.72 43.62,41.34 43.11,41.34 42.81,41.64 42.81,41.87 42.59,42.08 40.69,42.08 40.4,41.79 36.74,41.79 36.37,41.43 36.19,41.43 35.99,41.63 35.99,41.66 35.87,41.79 35.69,41.79 35.56,41.66 35.56,41.63 35.43,41.5 35.26,41.5 35.13,41.63 35.13,41.66 35,41.79 34.55,41.79 34.03,42.31 34.03,42.76 34.54,43.27 34.54,43.45 34.42,43.58 34.24,43.58 32.9,42.24 32.45,42.24 32.13,42.56 32.13,43.01 33.46,44.35 33.46,44.53 33.34,44.66 33.16,44.66 31.82,43.32 31.37,43.32 31.05,43.64 31.05,44.09 32.39,45.43 32.39,45.61 32.26,45.73 32.08,45.73 30.75,44.4 30.29,44.4 29.97,44.72 29.97,45.17 31.31,46.51 31.31,46.68 31.18,46.81 31,46.81 30.49,46.3 30.04,46.3 28.79,47.55 27.03,47.55 26.49,48.08 25.9,48.08 25.37,47.55 24.69,47.55 24.53,47.71 24.35,47.71 24.19,47.55 17.73,47.55 17.36,47.92 10.76,47.92 v2(10.29,47.45)
HA08_P: length 53.2
  TOP w0.152: v1(43.24,41.72) 43.64,41.32 U9.E5
  LY7-PWR w0.127: v2(10.29,48.72) 10.76,48.25 17.5,48.25 17.87,47.88 18.2,47.88 18.37,48.06 18.6,48.06 18.78,47.88 19.06,47.88 19.24,48.06 19.47,48.06 19.64,47.88 19.92,47.88 20.08,48.03 20.35,48.03 20.51,47.88 20.79,47.88 20.94,48.03 21.22,48.03 21.37,47.88 21.65,47.88 21.8,48.03 22.08,48.03 22.23,47.88 22.51,47.88 22.67,48.03 22.95,48.03 23.1,47.88 23.38,47.88 23.53,48.03 23.81,48.03 23.96,47.88 24.24,47.88 24.39,48.03 24.67,48.03 24.82,47.88 25.23,47.88 25.77,48.41 26.63,48.41 27.16,47.88 28.93,47.88 30.18,46.63 30.36,46.63 30.87,47.14 31.32,47.14 31.64,46.82 31.64,46.37 30.3,45.03 30.3,44.85 30.43,44.73 30.61,44.73 31.94,46.06 32.4,46.06 32.72,45.74 32.72,45.29 31.38,43.96 31.38,43.78 31.51,43.65 31.69,43.65 33.02,44.99 33.47,44.99 33.79,44.67 33.79,44.21 32.46,42.88 32.46,42.7 32.59,42.57 32.76,42.57 34.1,43.91 34.55,43.91 34.87,43.59 34.87,43.14 34.36,42.63 34.36,42.45 34.69,42.12 38.95,42.12 39.24,42.42 39.24,42.55 39.62,42.93 42.55,42.93 42.88,42.6 42.88,42.27 43.21,41.94 43.21,41.75 v1(43.24,41.72)
HA09_N: length 53.2
  TOP w0.127: U9.A5 v1(43.64,47.26)
  LY7-PWR w0.127: v2(11.56,48.72) 12.03,49.19 21.04,49.19 21.33,49.48 21.7,49.48 21.99,49.19 30.44,49.19 30.71,48.92 31.61,48.92 31.93,49.24 31.93,50.22 32.05,50.34 32.23,50.34 32.36,50.22 32.36,47.82 32.68,47.5 33.13,47.5 33.45,47.82 33.45,50.22 33.58,50.34 33.76,50.34 33.88,50.22 33.88,47.82 34.2,47.5 34.65,47.5 34.97,47.82 34.97,50.22 35.1,50.34 35.28,50.34 35.41,50.22 35.41,47.82 35.73,47.5 36.18,47.5 36.5,47.82 36.5,48.79 36.63,48.92 39.3,48.92 39.48,49.11 39.66,49.11 39.85,48.92 43.15,48.92 44.14,47.93 44.14,47.04 44.04,46.96 43.86,46.98 v1(43.64,47.26)
HA09_P: length 53.2
  TOP w0.127: U9.A6 v1(44.44,46.24)
  LY7-PWR w0.127: v2(11.56,49.99) 12.03,49.52 20.91,49.52 21.2,49.81 21.83,49.81 22.12,49.52 24.17,49.52 24.34,49.68 24.6,49.68 24.77,49.52 30.58,49.52 30.85,49.25 31.47,49.25 31.6,49.38 31.6,50.35 31.92,50.67 32.37,50.67 32.69,50.35 32.69,47.95 32.82,47.83 32.99,47.83 33.12,47.95 33.12,50.35 33.44,50.67 33.89,50.67 34.21,50.35 34.21,47.95 34.34,47.83 34.52,47.83 34.64,47.95 34.64,50.35 34.96,50.67 35.42,50.67 35.74,50.35 35.74,47.95 35.86,47.83 36.04,47.83 36.17,47.95 36.17,48.93 36.49,49.25 39.16,49.25 39.34,49.43 39.59,49.43 39.77,49.25 43.29,49.25 44.47,48.07 44.47,46.9 44.36,46.79 44.25,46.7 44.22,46.52 v1(44.44,46.24)
HA10_N: length 53.2
  TOP w0.152: U9.C1 v1(40.04,43.32)
  LY5-SIGNAL w0.127: v2(5.21,43.64) 5.68,44.11 17.45,44.11 17.58,43.98 17.58,43.14 17.92,42.8 19.06,42.8 19.41,43.14 19.41,43.68 19.53,43.81 19.87,43.81 19.99,43.68 19.99,43.14 20.31,42.82 20.77,42.82 21.09,43.14 21.09,43.68 21.21,43.81 21.39,43.81 21.52,43.68 21.52,43.14 21.84,42.82 22.29,42.82 22.61,43.14 22.61,43.68 22.74,43.81 22.92,43.81 23.04,43.68 23.04,43.14 23.36,42.82 23.82,42.82 24.14,43.14 24.14,43.68 24.26,43.81 24.44,43.81 24.57,43.68 24.57,43.14 24.89,42.82 25.34,42.82 25.66,43.14 25.66,43.68 25.79,43.81 25.96,43.81 26.09,43.68 26.09,43.14 26.41,42.82 26.86,42.82 27.18,43.14 27.18,43.68 27.31,43.81 27.49,43.81 27.61,43.68 27.61,43.14 27.93,42.82 28.39,42.82 28.71,43.14 28.71,43.68 28.83,43.81 29.01,43.81 29.14,43.68 29.14,43.14 29.46,42.82 29.91,42.82 30.23,43.14 30.23,43.68 30.36,43.81 30.54,43.81 30.66,43.68 30.66,43.14 30.98,42.82 31.44,42.82 31.76,43.14 31.76,43.68 31.88,43.81 32.06,43.81 32.19,43.68 32.19,43.14 32.51,42.82 32.96,42.82 33.28,43.14 33.28,43.68 33.41,43.81 33.58,43.81 33.71,43.68 33.71,43.14 34.03,42.82 34.68,42.82 35,43.14 35,43.68 35.13,43.81 35.37,43.81 35.51,43.66 35.8,43.66 35.94,43.81 36.23,43.81 36.46,43.58 36.64,43.58 36.87,43.81 37.09,43.81 37.24,43.66 37.53,43.66 37.67,43.81 37.96,43.81 38.08,43.69 38.41,43.69 38.54,43.81 38.92,43.81 39.04,43.69 39.38,43.69 39.5,43.81 40.15,43.81 40.28,43.68 40.28,43.55 v1(40.04,43.32)
HA10_P: length 53.2
  TOP w0.152: U9.C2 v1(40.84,43.32)
  LY5-SIGNAL w0.127: v1(40.84,43.32) 40.61,43.55 40.61,43.82 40.29,44.14 35.99,44.14 35.84,43.99 35.66,43.99 35.5,44.14 34.99,44.14 34.67,43.82 34.67,43.28 34.54,43.15 34.17,43.15 34.04,43.28 34.04,43.82 33.72,44.14 33.27,44.14 32.95,43.82 32.95,43.28 32.82,43.15 32.64,43.15 32.52,43.28 32.52,43.82 32.2,44.14 31.74,44.14 31.42,43.82 31.42,43.28 31.3,43.15 31.12,43.15 30.99,43.28 30.99,43.82 30.67,44.14 30.22,44.14 29.9,43.82 29.9,43.28 29.77,43.15 29.6,43.15 29.47,43.28 29.47,43.82 29.15,44.14 28.7,44.14 28.38,43.82 28.38,43.28 28.25,43.15 28.07,43.15 27.95,43.28 27.95,43.82 27.63,44.14 27.17,44.14 26.85,43.82 26.85,43.28 26.73,43.15 26.55,43.15 26.42,43.28 26.42,43.82 26.1,44.14 25.65,44.14 25.33,43.82 25.33,43.28 25.2,43.15 25.02,43.15 24.9,43.28 24.9,43.82 24.58,44.14 24.12,44.14 23.8,43.82 23.8,43.28 23.68,43.15 23.5,43.15 23.37,43.28 23.37,43.82 23.05,44.14 22.6,44.14 22.28,43.82 22.28,43.28 22.15,43.15 21.98,43.15 21.85,43.28 21.85,43.82 21.53,44.14 21.08,44.14 20.76,43.82 20.76,43.28 20.63,43.15 20.45,43.15 20.33,43.28 20.33,43.82 20.01,44.14 19.4,44.14 19.08,43.82 19.08,43.28 18.92,43.13 18.06,43.13 17.91,43.28 17.91,44.12 17.59,44.44 5.68,44.44 v2(5.21,44.91)
HA11_N: length 53.2
  TOP w0.152: U9.B4 v1(42.44,44.12)
  LY5-SIGNAL w0.127: v1(42.44,44.12) 42.44,45.22 42.29,45.38 41.73,45.38 41.59,45.24 41.3,45.24 41.16,45.38 40.93,45.38 40.61,45.06 40.31,45.06 40.14,45.24 40.14,45.25 40.01,45.38 39.83,45.38 39.7,45.25 39.7,45.24 39.58,45.11 39.4,45.11 39.27,45.24 39.27,45.25 39.15,45.38 38.97,45.38 38.84,45.25 38.84,45.24 38.71,45.11 38.54,45.11 38.41,45.24 38.41,45.25 38.28,45.38 38.1,45.38 37.98,45.25 37.98,45.24 37.85,45.11 37.67,45.11 37.55,45.24 37.55,45.25 37.42,45.38 37.24,45.38 37.11,45.25 37.11,45.24 36.99,45.11 36.81,45.11 36.68,45.24 36.68,45.25 36.56,45.38 36.38,45.38 36.25,45.25 36.25,45.24 36.12,45.11 35.94,45.11 35.82,45.24 35.82,45.25 35.69,45.38 35.04,45.38 34.29,44.63 33.78,44.63 33.18,45.23 33.18,45.72 33.06,45.85 32.88,45.85 32.75,45.72 32.75,45.23 32.43,44.91 31.98,44.91 31.66,45.23 31.66,45.72 31.53,45.85 31.35,45.85 31.23,45.72 31.23,45.23 30.91,44.91 30.45,44.91 30.13,45.23 30.13,45.72 30.01,45.85 29.83,45.85 29.7,45.72 29.7,45.23 29.38,44.91 28.93,44.91 28.61,45.23 28.61,45.72 28.48,45.85 28.31,45.85 28.18,45.72 28.18,45.23 27.86,44.91 27.41,44.91 27.09,45.23 27.09,45.72 26.96,45.85 26.78,45.85 26.65,45.72 26.65,45.23 26.34,44.91 25.88,44.91 25.56,45.23 25.56,45.72 25.44,45.85 25.26,45.85 25.13,45.72 25.13,45.23 24.81,44.91 24.36,44.91 24.04,45.23 24.04,45.72 23.91,45.85 23.73,45.85 23.61,45.72 23.61,45.23 23.29,44.91 22.83,44.91 22.51,45.23 22.51,45.72 22.39,45.85 22.21,45.85 22.08,45.72 22.08,45.23 21.76,44.91 21.31,44.91 20.99,45.23 20.99,45.72 20.86,45.85 20.69,45.85 20.56,45.72 20.56,45.23 20.24,44.91 19.79,44.91 19.47,45.23 19.47,45.72 19.34,45.85 19.16,45.85 19.03,45.72 19.03,45.7 18.72,45.38 18.03,45.38 17.73,45.67 17.43,45.67 17.14,45.38 6.95,45.38 v2(6.48,44.91)
HA11_P: length 53.2
  TOP w0.152: U9.C4 v1(42.44,43.32)
  LY5-SIGNAL w0.127: v1(42.44,43.32) 42.84,43.72 42.84,45.29 42.42,45.71 34.9,45.71 34.15,44.96 33.92,44.96 33.51,45.36 33.51,45.86 33.19,46.18 32.74,46.18 32.42,45.86 32.42,45.36 32.29,45.24 32.12,45.24 31.99,45.36 31.99,45.86 31.67,46.18 31.22,46.18 30.9,45.86 30.9,45.36 30.77,45.24 30.59,45.24 30.46,45.36 30.46,45.86 30.15,46.18 29.69,46.18 29.37,45.86 29.37,45.36 29.25,45.24 29.07,45.24 28.94,45.36 28.94,45.86 28.62,46.18 28.17,46.18 27.85,45.86 27.85,45.36 27.72,45.24 27.54,45.24 27.42,45.36 27.42,45.86 27.1,46.18 26.64,46.18 26.32,45.86 26.32,45.36 26.2,45.24 26.02,45.24 25.89,45.36 25.89,45.86 25.57,46.18 25.12,46.18 24.8,45.86 24.8,45.36 24.67,45.24 24.5,45.24 24.37,45.36 24.37,45.86 24.05,46.18 23.6,46.18 23.28,45.86 23.28,45.36 23.15,45.24 22.97,45.24 22.84,45.36 22.84,45.86 22.53,46.18 22.07,46.18 21.75,45.86 21.75,45.36 21.63,45.24 21.45,45.24 21.32,45.36 21.32,45.86 21,46.18 20.55,46.18 20.23,45.86 20.23,45.36 20.1,45.24 19.92,45.24 19.8,45.36 19.8,45.86 19.48,46.18 19.02,46.18 18.7,45.86 18.7,45.83 18.58,45.71 18.16,45.71 17.87,46 17.29,46 17,45.71 6.95,45.71 v2(6.48,46.18)
HA12_N: length 53.2
  TOP w0.152: U9.H1 v1(40.04,39.32)
  LY7-PWR w0.127: v1(40.04,39.32) 39.81,39.55 33.28,39.55 28.73,44.11 26.6,44.11 26.28,44.42 25.97,44.42 25.65,44.11 24.59,44.11 24.27,44.43 24.27,45.26 24.14,45.39 23.96,45.39 23.84,45.26 23.84,43.14 23.52,42.82 23.06,42.82 22.74,43.14 22.74,45.26 22.62,45.39 22.44,45.39 22.31,45.26 22.31,43.14 21.99,42.82 21.54,42.82 21.22,43.14 21.22,45.26 21.09,45.39 20.91,45.39 20.79,45.26 20.79,43.14 20.47,42.82 20.01,42.82 19.69,43.14 19.69,45.26 19.57,45.39 19.39,45.39 19.26,45.26 19.26,43.14 18.94,42.82 18.49,42.82 18.17,43.14 18.17,45.26 18.04,45.39 17.87,45.39 17.74,45.26 17.74,44.43 17.42,44.11 10.76,44.11 v2(10.29,43.64)
HA12_P: length 53.2
  TOP w0.152: U9.G1 v1(40.04,40.12)
  LY7-PWR w0.127: v2(10.29,44.91) 10.76,44.44 17.28,44.44 17.41,44.56 17.41,45.4 17.73,45.72 18.18,45.72 18.5,45.4 18.5,43.28 18.63,43.15 18.81,43.15 18.93,43.28 18.93,45.4 19.25,45.72 19.71,45.72 20.03,45.4 20.03,43.28 20.15,43.15 20.33,43.15 20.46,43.28 20.46,45.4 20.78,45.72 21.23,45.72 21.55,45.4 21.55,43.28 21.68,43.15 21.85,43.15 21.98,43.28 21.98,45.4 22.3,45.72 22.75,45.72 23.07,45.4 23.07,43.28 23.2,43.15 23.38,43.15 23.5,43.28 23.5,45.4 23.82,45.72 24.28,45.72 24.6,45.4 24.6,44.56 24.72,44.44 25.51,44.44 25.83,44.75 26.41,44.75 26.73,44.44 28.87,44.44 33.42,39.88 39.81,39.88 v1(40.04,40.12)
HA13_N: length 53.2
  TOP w0.152: U9.B2 v1(40.84,44.12)
  LY3-SIGNAL w0.127: v2(11.56,44.91) 12.03,45.38 18.42,45.38 18.91,44.88 20.5,44.88 20.63,44.76 20.63,44.44 20.95,44.12 21.4,44.12 21.72,44.44 21.72,45.52 21.85,45.64 22.03,45.64 22.15,45.52 22.15,44.44 22.47,44.12 22.92,44.12 23.24,44.44 23.24,45.52 23.37,45.64 23.55,45.64 23.68,45.52 23.68,44.44 24,44.12 24.45,44.12 24.77,44.44 24.77,45.52 24.89,45.64 25.07,45.64 25.2,45.52 25.2,44.44 25.52,44.12 25.97,44.12 26.29,44.44 26.29,45.52 26.42,45.64 26.6,45.64 26.72,45.52 26.72,44.44 27.04,44.12 27.5,44.12 27.82,44.44 27.82,45.52 27.94,45.64 28.12,45.64 28.25,45.52 28.25,44.44 28.57,44.12 29.02,44.12 29.34,44.44 29.34,45.52 29.47,45.64 29.65,45.64 29.77,45.52 29.77,44.44 30.09,44.12 30.54,44.12 30.86,44.44 30.86,45.52 30.99,45.64 31.17,45.64 31.3,45.52 31.3,44.44 31.62,44.12 32.07,44.12 32.39,44.44 32.39,45.52 32.51,45.64 32.69,45.64 32.82,45.52 32.82,44.44 33.14,44.12 33.59,44.12 33.91,44.44 33.91,44.76 34.04,44.88 34.4,44.88 34.58,44.7 34.84,44.7 35.01,44.88 36.4,44.88 36.58,44.7 36.89,44.7 37.06,44.88 37.27,44.88 37.48,44.67 37.66,44.67 37.88,44.88 38.13,44.88 38.31,44.7 38.73,44.7 38.91,44.88 41.02,44.88 41.15,44.75 41.15,44.42 v1(40.84,44.12)
HA13_P: length 53.2
  TOP w0.152: U9.B3 v1(41.64,44.12)
  LY3-SIGNAL w0.127: v1(41.64,44.12) 41.48,44.28 41.48,44.89 41.16,45.21 37.09,45.21 36.9,45.03 36.72,45.03 36.54,45.21 33.9,45.21 33.58,44.89 33.58,44.58 33.46,44.45 33.28,44.45 33.15,44.58 33.15,45.65 32.83,45.97 32.38,45.97 32.06,45.65 32.06,44.58 31.93,44.45 31.75,44.45 31.63,44.58 31.63,45.65 31.31,45.97 30.85,45.97 30.53,45.65 30.53,44.58 30.41,44.45 30.23,44.45 30.1,44.58 30.1,45.65 29.78,45.97 29.33,45.97 29.01,45.65 29.01,44.58 28.88,44.45 28.7,44.45 28.58,44.58 28.58,45.65 28.26,45.97 27.81,45.97 27.49,45.65 27.49,44.58 27.36,44.45 27.18,44.45 27.05,44.58 27.05,45.65 26.73,45.97 26.28,45.97 25.96,45.65 25.96,44.58 25.84,44.45 25.66,44.45 25.53,44.58 25.53,45.65 25.21,45.97 24.76,45.97 24.44,45.65 24.44,44.58 24.31,44.45 24.13,44.45 24.01,44.58 24.01,45.65 23.69,45.97 23.23,45.97 22.91,45.65 22.91,44.58 22.79,44.45 22.61,44.45 22.48,44.58 22.48,45.65 22.16,45.97 21.71,45.97 21.39,45.65 21.39,44.58 21.26,44.45 21.08,44.45 20.96,44.58 20.96,44.89 20.64,45.21 19.05,45.21 18.55,45.71 12.03,45.71 v2(11.56,46.18)
HA14_N: length 53.2
  TOP w0.152: v1(44.04,43.32) 44.44,42.92 U9.C6
  LY5-SIGNAL w0.127: v1(44.04,43.32) 43.95,43.32 43.61,42.97 43.61,42.37 43.33,42.08 43.09,42.08 39.98,42.08 39.68,41.78 31.65,41.78 31.47,41.61 30.63,41.61 30.35,41.89 30.35,42.01 30.22,42.14 30.04,42.14 29.92,42.01 29.92,41.32 29.6,41 29.15,41 28.83,41.32 28.83,42.01 28.7,42.14 28.52,42.14 28.39,42.01 28.39,41.32 28.07,41 27.62,41 27.3,41.32 27.3,42.01 27.18,42.14 27,42.14 26.87,42.01 26.87,41.32 26.55,41 26.1,41 25.78,41.32 25.78,42.01 25.65,42.14 25.47,42.14 25.35,42.01 25.35,41.32 25.03,41 24.57,41 24.25,41.32 24.25,42.01 24.13,42.14 23.95,42.14 23.82,42.01 23.82,41.32 23.5,41 23.05,41 22.73,41.32 22.73,42.01 22.6,42.14 22.42,42.14 22.3,42.01 22.3,41.32 21.98,41 21.53,41 21.21,41.32 21.21,42.01 21.08,42.14 20.9,42.14 20.77,42.01 20.77,41.32 20.45,41 20,41 19.68,41.32 19.68,42.01 19.56,42.14 19.38,42.14 19.25,42.01 19.25,41.32 18.93,41 18.48,41 18.16,41.32 18.16,41.44 18.03,41.57 6.95,41.57 v2(6.48,41.1)
HA14_P: length 53.2
  TOP w0.152: v1(43.24,43.32) 43.64,42.92 U9.C5
  LY5-SIGNAL w0.127: v1(43.24,43.32) 42.81,42.88 39.66,42.88 38.89,42.11 37.9,42.11 37.59,42.42 37.16,42.42 36.85,42.11 36.57,42.11 36.37,42.32 36.19,42.32 35.99,42.11 35.71,42.11 35.46,42.37 35.26,42.37 35.01,42.13 34.83,42.13 34.69,42.27 34.42,42.27 34.26,42.11 33.89,42.11 33.64,42.37 33.45,42.37 33.2,42.12 33.02,42.12 32.83,42.32 32.65,42.32 32.44,42.11 32.16,42.11 31.96,42.32 31.78,42.32 31.58,42.11 31.51,42.11 31.33,41.94 30.77,41.94 30.68,42.02 30.68,42.15 30.36,42.47 29.91,42.47 29.59,42.15 29.59,41.45 29.46,41.33 29.28,41.33 29.16,41.45 29.16,42.15 28.84,42.47 28.38,42.47 28.06,42.15 28.06,41.45 27.94,41.33 27.76,41.33 27.63,41.45 27.63,42.15 27.31,42.47 26.86,42.47 26.54,42.15 26.54,41.45 26.41,41.33 26.23,41.33 26.11,41.45 26.11,42.15 25.79,42.47 25.34,42.47 25.02,42.15 25.02,41.45 24.89,41.33 24.71,41.33 24.58,41.45 24.58,42.15 24.26,42.47 23.81,42.47 23.49,42.15 23.49,41.45 23.37,41.33 23.19,41.33 23.06,41.45 23.06,42.15 22.74,42.47 22.29,42.47 21.97,42.15 21.97,41.45 21.84,41.33 21.66,41.33 21.54,41.45 21.54,42.15 21.22,42.47 20.76,42.47 20.44,42.15 20.44,41.45 20.32,41.33 20.14,41.33 20.01,41.45 20.01,42.15 19.69,42.47 19.24,42.47 18.92,42.15 18.92,41.45 18.79,41.33 18.61,41.33 18.49,41.45 18.49,41.58 18.17,41.9 6.95,41.9 v2(6.48,42.37)
HA15_N: length 53.2
  TOP w0.152: U9.J3 v1(41.64,38.52)
  LY7-PWR w0.127: v1(41.64,38.52) 41.2,38.08 40.71,38.08 40.3,38.48 39.77,38.48 39.71,38.42 38.52,38.42 38.46,38.48 31.37,38.48 29.55,40.3 29.17,40.3 28.63,40.84 28.1,40.84 27.55,40.3 26.33,40.3 26.01,40.62 26.01,41.2 25.88,41.33 25.7,41.33 25.58,41.2 25.58,39.59 25.26,39.27 24.81,39.27 24.49,39.59 24.49,41.2 24.36,41.33 24.18,41.33 24.05,41.2 24.05,39.59 23.73,39.27 23.28,39.27 22.96,39.59 22.96,41.2 22.83,41.33 22.66,41.33 22.53,41.2 22.53,39.59 22.21,39.27 21.76,39.27 21.44,39.59 21.44,41.2 21.31,41.33 21.13,41.33 21.01,41.2 21.01,39.59 20.69,39.27 20.23,39.27 19.91,39.59 19.91,41.2 19.79,41.33 19.61,41.33 19.48,41.2 19.48,39.59 19.16,39.27 18.71,39.27 18.39,39.59 18.39,41.2 18.26,41.33 18.08,41.33 17.96,41.2 17.96,40.62 17.64,40.3 10.76,40.3 v2(10.29,39.83)
HA15_P: length 53.2
  TOP w0.152: U9.J2 v1(40.84,38.52)
  LY7-PWR w0.127: v2(10.29,41.1) 10.76,40.63 17.5,40.63 17.63,40.75 17.63,41.34 17.95,41.66 18.4,41.66 18.72,41.34 18.72,39.73 18.85,39.6 19.02,39.6 19.15,39.73 19.15,41.34 19.47,41.66 19.92,41.66 20.24,41.34 20.24,39.73 20.37,39.6 20.55,39.6 20.68,39.73 20.68,41.34 21,41.66 21.45,41.66 21.77,41.34 21.77,39.73 21.89,39.6 22.07,39.6 22.2,39.73 22.2,41.34 22.52,41.66 22.97,41.66 23.29,41.34 23.29,39.73 23.42,39.6 23.6,39.6 23.72,39.73 23.72,41.34 24.04,41.66 24.5,41.66 24.82,41.34 24.82,39.73 24.94,39.6 25.12,39.6 25.25,39.73 25.25,41.34 25.57,41.66 26.02,41.66 26.34,41.34 26.34,40.75 26.47,40.63 27.42,40.63 27.96,41.17 28.76,41.17 29.31,40.63 29.69,40.63 31.5,38.81 31.73,38.81 31.91,38.99 32.16,38.99 32.34,38.81 32.59,38.81 32.77,38.99 33.03,38.99 33.2,38.81 33.46,38.81 33.63,38.99 33.89,38.99 34.07,38.81 34.32,38.81 34.5,38.99 34.75,38.99 34.93,38.81 35.19,38.81 35.36,38.99 35.62,38.99 35.79,38.81 36.05,38.81 36.22,38.99 36.48,38.99 36.66,38.81 36.91,38.81 37.09,38.99 37.34,38.99 37.52,38.81 38.6,38.81 38.66,38.75 39.57,38.75 39.64,38.81 40.44,38.81 40.73,38.52 v1(40.84,38.52)
HA16_N: length 53.2
  TOP w0.152: U9.E2 v1(40.84,41.72)
  LY3-SIGNAL w0.127: v2(11.56,41.1) 12.03,41.57 18.05,41.57 18.77,42.29 19.47,42.29 19.6,42.16 19.6,41.82 19.92,41.5 20.37,41.5 20.69,41.82 20.69,42.95 20.82,43.08 21,43.08 21.12,42.95 21.12,41.82 21.44,41.5 21.9,41.5 22.22,41.82 22.22,42.95 22.34,43.08 22.52,43.08 22.65,42.95 22.65,41.82 22.97,41.5 23.42,41.5 23.74,41.82 23.74,42.95 23.87,43.08 24.04,43.08 24.17,42.95 24.17,41.82 24.49,41.5 24.94,41.5 25.26,41.82 25.26,42.95 25.39,43.08 25.57,43.08 25.69,42.95 25.69,41.82 26.01,41.5 26.47,41.5 26.79,41.82 26.79,42.95 26.91,43.08 27.09,43.08 27.22,42.95 27.22,41.82 27.54,41.5 27.99,41.5 28.31,41.82 28.31,42.95 28.44,43.08 28.62,43.08 28.74,42.95 28.74,41.82 29.06,41.5 29.52,41.5 29.84,41.82 29.84,42.95 29.96,43.08 30.14,43.08 30.27,42.95 30.27,41.82 30.59,41.5 31.04,41.5 31.36,41.82 31.36,42.95 31.49,43.08 31.66,43.08 31.79,42.95 31.79,41.82 32.11,41.5 32.56,41.5 32.88,41.82 32.88,42.16 33.16,42.44 34.01,42.44 35.05,41.4 35.28,41.4 35.43,41.25 35.71,41.25 35.86,41.4 40.19,41.4 40.27,41.48 40.45,41.48 40.53,41.4 v1(40.84,41.72)
HA16_P: length 53.2
  TOP w0.152: U9.D2 v1(40.84,42.52)
  LY3-SIGNAL w0.127: v1(40.84,42.52) 40.06,41.73 35.19,41.73 34.15,42.77 33.03,42.77 32.55,42.3 32.55,41.96 32.43,41.83 32.25,41.83 32.12,41.96 32.12,43.09 31.8,43.41 31.35,43.41 31.03,43.09 31.03,41.96 30.9,41.83 30.72,41.83 30.6,41.96 30.6,43.09 30.28,43.41 29.82,43.41 29.5,43.09 29.5,41.96 29.38,41.83 29.2,41.83 29.07,41.96 29.07,43.09 28.75,43.41 28.3,43.41 27.98,43.09 27.98,41.96 27.85,41.83 27.68,41.83 27.55,41.96 27.55,43.09 27.23,43.41 26.78,43.41 26.46,43.09 26.46,41.96 26.33,41.83 26.15,41.83 26.03,41.96 26.03,43.09 25.71,43.41 25.25,43.41 24.93,43.09 24.93,41.96 24.81,41.83 24.63,41.83 24.5,41.96 24.5,43.09 24.18,43.41 23.73,43.41 23.41,43.09 23.41,41.96 23.28,41.83 23.1,41.83 22.98,41.96 22.98,43.09 22.66,43.41 22.2,43.41 21.88,43.09 21.88,41.96 21.76,41.83 21.58,41.83 21.45,41.96 21.45,43.09 21.13,43.41 20.68,43.41 20.36,43.09 20.36,41.96 20.23,41.83 20.06,41.83 19.93,41.96 19.93,42.3 19.61,42.62 18.63,42.62 17.91,41.9 12.03,41.9 v2(11.56,42.37)
HA18_N: length 53.2
  TOP w0.152: U9.H6 v1(44.04,39.32)
  LY5-SIGNAL w0.127: v2(6.48,37.29) 6.95,37.76 19.27,37.76 19.63,37.39 20.32,37.39 20.45,37.26 20.45,36.46 20.77,36.14 21.22,36.14 21.54,36.46 21.54,37.8 21.67,37.92 21.85,37.92 21.97,37.8 21.97,36.46 22.29,36.14 22.74,36.14 23.06,36.46 23.06,37.74 23.19,37.87 23.37,37.87 23.5,37.74 23.5,36.46 23.82,36.14 24.27,36.14 24.59,36.46 24.59,37.97 24.72,38.1 25.6,38.1 25.73,37.97 25.73,37.71 26.05,37.39 27.27,37.39 27.45,37.57 27.63,37.57 27.82,37.39 28.5,37.39 28.82,37.71 28.82,38.05 28.95,38.18 29.13,38.18 29.25,38.05 29.25,36.92 29.57,36.6 30.03,36.6 30.35,36.92 30.35,38.05 30.47,38.18 30.65,38.18 30.78,38.05 30.78,37.71 31.1,37.39 32.06,37.39 32.27,37.59 32.84,37.59 33.05,37.39 34.75,37.39 34.9,37.54 34.91,37.54 35.06,37.39 43.36,37.39 43.68,37.71 43.68,38.67 43.81,38.8 43.81,39.08 v1(44.04,39.32)
HA18_P: length 53.2
  TOP w0.152: U9.H5 v1(43.24,39.32)
  LY5-SIGNAL w0.127: v1(43.24,39.32) 43.48,39.08 43.48,38.94 43.35,38.81 43.35,37.85 43.22,37.72 36.92,37.72 36.77,37.87 36.49,37.87 36.34,37.72 36.06,37.72 35.91,37.87 35.63,37.87 35.48,37.72 35.2,37.72 35.04,37.87 34.77,37.87 34.61,37.72 33.18,37.72 32.98,37.92 32.13,37.92 31.93,37.72 31.24,37.72 31.11,37.85 31.11,38.19 30.79,38.51 30.34,38.51 30.02,38.19 30.02,37.06 29.89,36.93 29.71,36.93 29.59,37.06 29.59,38.19 29.27,38.51 28.81,38.51 28.49,38.19 28.49,37.85 28.37,37.72 27.96,37.72 27.78,37.9 27.52,37.9 27.35,37.72 26.19,37.72 26.06,37.85 26.06,38.11 25.74,38.43 24.58,38.43 24.26,38.11 24.26,36.6 24.13,36.47 23.95,36.47 23.83,36.6 23.83,37.88 23.51,38.2 23.05,38.2 22.73,37.88 22.73,36.6 22.61,36.47 22.43,36.47 22.3,36.6 22.3,37.93 21.98,38.25 21.53,38.25 21.21,37.93 21.21,36.6 21.08,36.47 20.91,36.47 20.78,36.6 20.78,37.4 20.46,37.72 19.77,37.72 19.4,38.09 18.76,38.09 18.59,38.25 18.25,38.25 18.08,38.09 17.89,38.09 17.73,38.25 17.39,38.25 17.22,38.09 6.95,38.09 v2(6.48,38.56)
HA19_N: length 53.2
  TOP w0.127: U9.K2 v1(40.84,36.92)
  LY7-PWR w0.127: v2(10.29,36.02) 10.76,36.49 17.23,36.49 17.81,35.92 17.81,34.37 18.21,33.96 20.3,33.96 20.73,34.39 20.92,34.39 21.05,34.27 21.05,33.67 21.37,33.35 21.82,33.35 22.14,33.67 22.14,34.44 22.27,34.57 22.45,34.57 22.57,34.44 22.57,33.67 22.89,33.35 23.34,33.35 23.66,33.67 23.66,34.44 23.79,34.57 23.97,34.57 24.1,34.44 24.1,33.67 24.42,33.35 24.87,33.35 25.19,33.67 25.19,34.44 25.31,34.57 25.49,34.57 25.62,34.44 25.62,33.67 25.94,33.35 26.39,33.35 26.71,33.67 26.71,34.44 26.84,34.57 27.02,34.57 27.14,34.44 27.14,33.67 27.46,33.35 27.92,33.35 28.24,33.67 28.24,34.44 28.36,34.57 28.54,34.57 28.67,34.44 28.67,33.67 28.99,33.35 29.44,33.35 29.76,33.67 29.76,34.44 29.89,34.57 30.07,34.57 30.19,34.44 30.19,33.67 30.51,33.35 30.96,33.35 31.28,33.67 31.28,34.44 31.41,34.57 31.59,34.57 31.72,34.44 31.72,33.67 32.04,33.35 32.49,33.35 32.81,33.67 32.81,34.44 32.93,34.57 33.11,34.57 33.24,34.44 33.24,33.67 33.56,33.35 34.01,33.35 34.33,33.67 34.33,34.44 34.46,34.57 34.64,34.57 34.76,34.44 34.76,33.67 35.08,33.35 35.54,33.35 35.86,33.67 35.86,33.83 35.98,33.96 38.15,33.96 40.61,36.42 40.61,36.68 v1(40.84,36.92)
HA19_P: length 53.2
  TOP w0.127: U9.K1 v1(40.04,36.92)
  LY7-PWR w0.127: v2(10.29,37.29) 10.76,36.82 17.37,36.82 18.14,36.05 18.14,35.78 18.34,35.58 18.34,35.35 18.14,35.15 18.14,34.5 18.35,34.29 18.68,34.29 18.81,34.42 18.81,34.42 18.93,34.54 19.11,34.54 19.24,34.42 19.24,34.42 19.37,34.29 20.16,34.29 20.59,34.72 21.06,34.72 21.38,34.4 21.38,33.81 21.5,33.68 21.68,33.68 21.81,33.81 21.81,34.58 22.13,34.9 22.58,34.9 22.9,34.58 22.9,33.81 23.03,33.68 23.21,33.68 23.33,33.81 23.33,34.58 23.65,34.9 24.11,34.9 24.43,34.58 24.43,33.81 24.55,33.68 24.73,33.68 24.86,33.81 24.86,34.58 25.18,34.9 25.63,34.9 25.95,34.58 25.95,33.81 26.08,33.68 26.26,33.68 26.38,33.81 26.38,34.58 26.7,34.9 27.15,34.9 27.47,34.58 27.47,33.81 27.6,33.68 27.78,33.68 27.91,33.81 27.91,34.58 28.23,34.9 28.68,34.9 29,34.58 29,33.81 29.12,33.68 29.3,33.68 29.43,33.81 29.43,34.58 29.75,34.9 30.2,34.9 30.52,34.58 30.52,33.81 30.65,33.68 30.83,33.68 30.95,33.81 30.95,34.58 31.27,34.9 31.73,34.9 32.05,34.58 32.05,33.81 32.17,33.68 32.35,33.68 32.48,33.81 32.48,34.58 32.8,34.9 33.25,34.9 33.57,34.58 33.57,33.81 33.7,33.68 33.88,33.68 34,33.81 34,34.58 34.32,34.9 34.77,34.9 35.09,34.58 35.09,33.81 35.22,33.68 35.4,33.68 35.53,33.81 35.53,33.97 35.85,34.29 38.01,34.29 38.55,34.83 38.55,35.17 38.68,35.3 39.02,35.3 40.28,36.56 40.28,36.68 v1(40.04,36.92)
HA20_N: length 53.2
  TOP w0.152: U9.H4 v1(42.44,39.32)
  LY7-PWR w0.127: v2(11.56,37.29) 12.03,37.76 22.06,37.76 22.22,37.92 22.4,37.92 22.56,37.76 23.06,37.76 23.38,38.08 23.38,38.15 23.51,38.28 23.69,38.28 23.81,38.15 23.81,37.56 24.13,37.24 24.59,37.24 24.91,37.56 24.91,37.63 25.38,38.11 26.06,38.11 27.03,37.13 27.56,37.13 27.88,37.45 27.88,38.58 28.01,38.71 28.19,38.71 28.31,38.58 28.31,35.88 28.63,35.56 29.09,35.56 29.41,35.88 29.41,38.58 29.53,38.71 29.71,38.71 29.84,38.58 29.84,37.45 30.16,37.13 31.14,37.13 31.46,37.45 31.46,37.7 31.59,37.82 31.77,37.82 31.9,37.7 31.9,36.77 32.22,36.45 32.67,36.45 32.99,36.77 32.99,37.7 33.12,37.82 33.29,37.82 33.42,37.7 33.42,36.77 33.74,36.45 34.19,36.45 34.51,36.77 34.51,37.7 34.64,37.82 34.82,37.82 34.94,37.7 34.94,36.77 35.26,36.45 35.72,36.45 36.04,36.77 36.04,37.7 36.16,37.82 36.34,37.82 36.47,37.7 36.47,36.77 36.79,36.45 37.24,36.45 37.56,36.77 37.56,37.01 37.69,37.13 39.74,37.13 39.89,37.28 40.19,37.28 40.34,37.13 40.54,37.13 40.69,37.28 40.99,37.28 41.14,37.13 42.05,37.13 42.81,37.9 42.81,38.96 42.45,39.32 v1(42.44,39.32)
HA20_P: length 53.2
  TOP w0.152: U9.J4 v1(42.44,38.52)
  LY7-PWR w0.127: v2(11.56,38.56) 12.03,38.09 17.11,38.09 17.53,38.51 17.96,38.51 18.38,38.09 18.62,38.09 18.81,38.28 19.05,38.28 19.24,38.09 19.65,38.09 19.79,38.23 19.97,38.23 20.11,38.09 20.35,38.09 20.54,38.28 20.78,38.28 20.97,38.09 21.21,38.09 21.4,38.28 21.64,38.28 21.83,38.09 21.92,38.09 22.08,38.25 22.23,38.25 22.26,38.28 22.51,38.28 22.7,38.09 22.92,38.09 23.05,38.21 23.05,38.29 23.37,38.61 23.82,38.61 24.14,38.29 24.14,37.69 24.27,37.57 24.45,37.57 24.58,37.69 24.58,37.77 25.24,38.44 25.49,38.44 25.68,38.63 25.97,38.63 26.17,38.44 26.19,38.44 26.35,38.27 26.53,38.27 26.6,38.34 26.78,38.34 26.91,38.22 26.91,38.04 26.84,37.97 26.84,37.79 27.16,37.47 27.43,37.47 27.55,37.59 27.55,38.72 27.87,39.04 28.32,39.04 28.64,38.72 28.64,36.02 28.77,35.89 28.95,35.89 29.08,36.02 29.08,38.72 29.4,39.04 29.85,39.04 30.17,38.72 30.17,37.59 30.29,37.47 31.01,37.47 31.13,37.59 31.13,37.83 31.45,38.15 31.91,38.15 32.23,37.83 32.23,36.9 32.35,36.78 32.53,36.78 32.66,36.9 32.66,37.83 32.98,38.15 33.43,38.15 33.75,37.83 33.75,36.9 33.88,36.78 34.06,36.78 34.18,36.9 34.18,37.83 34.5,38.15 34.95,38.15 35.27,37.83 35.27,36.9 35.4,36.78 35.58,36.78 35.71,36.9 35.71,37.83 36.03,38.15 36.48,38.15 36.8,37.83 36.8,36.9 36.93,36.78 37.1,36.78 37.23,36.9 37.23,37.15 37.55,37.47 39.61,37.47 39.76,37.61 40.33,37.61 40.44,37.5 40.56,37.61 41.13,37.61 41.28,37.47 41.91,37.47 42.48,38.03 42.48,38.5 42.46,38.52 v1(42.44,38.52)
HA21_N: length 53.2
  TOP w0.152: U9.H2 v1(40.84,39.32)
  LY3-SIGNAL w0.127: v1(40.84,39.32) 40.74,39.21 40.74,39.03 40.19,38.48 40,38.48 40,38.48 39.77,38.48 38.69,37.4 37.44,37.4 37.25,37.59 29.55,37.59 29.14,38 28.92,38 28.52,37.59 27.33,37.59 27.21,37.47 27.21,36.95 26.89,36.63 26.44,36.63 26.12,36.95 26.12,38.43 25.99,38.56 25.81,38.56 25.68,38.43 25.68,36.95 25.36,36.63 24.91,36.63 24.59,36.95 24.59,38.43 24.46,38.56 24.29,38.56 24.16,38.43 24.16,36.95 23.84,36.63 23.39,36.63 23.07,36.95 23.07,38.43 22.94,38.56 22.76,38.56 22.64,38.43 22.64,36.95 22.32,36.63 21.86,36.63 21.54,36.95 21.54,38.43 21.42,38.56 21.24,38.56 21.11,38.43 21.11,37.91 20.79,37.59 20.07,37.59 19.6,37.13 19.6,37 19.3,36.69 19.17,36.69 18.99,36.52 18.99,36.26 18.81,36.08 18.56,36.08 18.38,35.91 18.38,35.65 18.2,35.47 17.95,35.47 17.65,35.18 7.31,35.18 6.99,35.5 6.99,36.32 6.82,36.49 5.68,36.49 v2(5.21,36.02)
HA21_P: length 53.2
  TOP w0.152: U9.G2 v1(40.84,40.12)
  LY3-SIGNAL w0.127: v1(40.84,40.12) 40.41,39.68 40.41,39.17 40.05,38.81 39.86,38.81 39.86,38.81 39.63,38.81 38.56,37.73 37.58,37.73 37.39,37.92 29.69,37.92 29.28,38.33 28.79,38.33 28.38,37.92 27.2,37.92 26.88,37.6 26.88,37.08 26.75,36.96 26.57,36.96 26.45,37.08 26.45,38.57 26.13,38.89 25.67,38.89 25.35,38.57 25.35,37.08 25.23,36.96 25.05,36.96 24.92,37.08 24.92,38.57 24.6,38.89 24.15,38.89 23.83,38.57 23.83,37.08 23.7,36.96 23.52,36.96 23.4,37.08 23.4,38.57 23.08,38.89 22.63,38.89 22.31,38.57 22.31,37.08 22.18,36.96 22,36.96 21.87,37.08 21.87,38.57 21.55,38.89 21.1,38.89 20.78,38.57 20.78,38.05 20.65,37.92 19.93,37.92 17.52,35.51 7.44,35.51 7.32,35.64 7.32,36.46 6.96,36.82 5.68,36.82 v2(5.21,37.29)
